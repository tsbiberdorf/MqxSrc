# Keil uVision project hvac_twrk60d100m.uvproj, settings and files
target hvac Int Flash Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: hvac +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../lib/twrk60d100m.uv4/debug/bsp/Generated_Code;../../../../lib/twrk60d100m.uv4/debug/bsp/Sources;../../../../lib/twrk60d100m.uv4/debug/rtcs;../../../../lib/twrk60d100m.uv4/debug;../../../../demo/hvac;../../../../lib/twrk60d100m.uv4/debug/usb;../../../../lib/twrk60d100m.uv4/debug/shell;../../../../lib/twrk60d100m.uv4/debug/mfs;../../../../lib/twrk60d100m.uv4/debug/psp;../../../../lib/twrk60d100m.uv4/debug/bsp
  asm define: _DEBUG=1
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../lib/twrk60d100m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../lib/twrk60d100m.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../lib/twrk60d100m.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group Source
    ../../../../demo/hvac/: HVAC_Private.h HVAC_Public.h HVAC_IO.c HVAC_Shell_Commands.h Shell_Task.c Command_Lists.c USB_Task.h usb_classes.h Logging_public.h RTCS.c Switch_Task.c HVAC_Shell_Commands.c USB_File.h Tasks.c HVAC.h HVAC_Util.c USB_File.c Logging_private.h Logging_Task.c usb_classes.c USB_Task.c HVAC_Task.c
  group MQX Libraries
    ../../../../lib/twrk60d100m.uv4/release/usb/: usbh.lib
    ../../../../lib/twrk60d100m.uv4/release/rtcs/: rtcs.lib
    ../../../../lib/twrk60d100m.uv4/debug/bsp/: bsp.lib
    ../../../../lib/twrk60d100m.uv4/release/psp/: psp.lib
    ../../../../lib/twrk60d100m.uv4/release/shell/: shell.lib
    ../../../../lib/twrk60d100m.uv4/debug/shell/: shell.lib
    ../../../../lib/twrk60d100m.uv4/debug/rtcs/: rtcs.lib
    ../../../../lib/twrk60d100m.uv4/release/bsp/: bsp.lib
    ../../../../lib/twrk60d100m.uv4/debug/usb/: usbh.lib
    ../../../../lib/twrk60d100m.uv4/release/mfs/: mfs.lib
    ../../../../lib/twrk60d100m.uv4/debug/mfs/: mfs.lib
    ../../../../lib/twrk60d100m.uv4/debug/psp/: psp.lib
target hvac Int Flash Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: hvac +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ../../../../lib/twrk60d100m.uv4/release/bsp/Generated_Code;../../../../demo/hvac;../../../../lib/twrk60d100m.uv4/release/bsp;../../../../lib/twrk60d100m.uv4/release/shell;../../../../lib/twrk60d100m.uv4/release/mfs;../../../../lib/twrk60d100m.uv4/release/psp;../../../../lib/twrk60d100m.uv4/release/bsp/Sources;../../../../lib/twrk60d100m.uv4/release;../../../../lib/twrk60d100m.uv4/release/rtcs;../../../../lib/twrk60d100m.uv4/release/usb
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../lib/twrk60d100m.uv4/release/bsp/intflash.scf
  link misc: ../../../../lib/twrk60d100m.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../lib/twrk60d100m.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
