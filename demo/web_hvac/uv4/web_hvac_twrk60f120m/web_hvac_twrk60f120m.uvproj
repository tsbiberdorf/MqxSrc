# Keil uVision project web_hvac_twrk60f120m.uvproj, settings and files
target web_hvac Int Flash Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: web_hvac +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../lib/twrk60f120m.uv4/debug/mfs;../../../../lib/twrk60f120m.uv4/debug/bsp/Sources;../../../../lib/twrk60f120m.uv4/debug/bsp/Generated_Code;../../../../lib/twrk60f120m.uv4/debug/psp;../../../../lib/twrk60f120m.uv4/debug/shell;../../../../lib/twrk60f120m.uv4/debug/rtcs;../../../../lib/twrk60f120m.uv4/debug;../../../../lib/twrk60f120m.uv4/debug/usb;../../../../lib/twrk60f120m.uv4/debug/bsp;../../../../demo/web_hvac
  asm define: _DEBUG=1
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../lib/twrk60f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../lib/twrk60f120m.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../lib/twrk60f120m.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group Source
    ../../../../demo/web_hvac/: USB_Task.h usb_classes.c HVAC_Util.c Command_Lists.c cgi_index.c HVAC_Private.h Logging_Task.c tfs_data.c cgi_hvac.c USB_File.c HVAC_Public.h Switch_Task.c HVAC_Shell_Commands.h Logging_private.h HVAC_Task.c HVAC_Shell_Commands.c HVAC.h RTCS.c cgi.h Shell_Task.c usb_classes.h HVAC_IO.c Logging_public.h USB_Task.c USB_File.h Tasks.c
  group MQX Libraries
    ../../../../lib/twrk60f120m.uv4/debug/shell/: shell.lib
    ../../../../lib/twrk60f120m.uv4/release/usb/: usbh.lib
    ../../../../lib/twrk60f120m.uv4/debug/usb/: usbh.lib
    ../../../../lib/twrk60f120m.uv4/debug/rtcs/: rtcs.lib
    ../../../../lib/twrk60f120m.uv4/debug/bsp/: bsp.lib
    ../../../../lib/twrk60f120m.uv4/release/shell/: shell.lib
    ../../../../lib/twrk60f120m.uv4/debug/mfs/: mfs.lib
    ../../../../lib/twrk60f120m.uv4/release/psp/: psp.lib
    ../../../../lib/twrk60f120m.uv4/release/mfs/: mfs.lib
    ../../../../lib/twrk60f120m.uv4/debug/psp/: psp.lib
    ../../../../lib/twrk60f120m.uv4/release/rtcs/: rtcs.lib
    ../../../../lib/twrk60f120m.uv4/release/bsp/: bsp.lib
target web_hvac Int Flash Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: web_hvac +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ../../../../lib/twrk60f120m.uv4/release/bsp/Generated_Code;../../../../lib/twrk60f120m.uv4/release/psp;../../../../lib/twrk60f120m.uv4/release/bsp/Sources;../../../../lib/twrk60f120m.uv4/release/shell;../../../../lib/twrk60f120m.uv4/release/rtcs;../../../../lib/twrk60f120m.uv4/release/bsp;../../../../lib/twrk60f120m.uv4/release;../../../../lib/twrk60f120m.uv4/release/usb;../../../../lib/twrk60f120m.uv4/release/mfs;../../../../demo/web_hvac
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../lib/twrk60f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../lib/twrk60f120m.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../lib/twrk60f120m.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
