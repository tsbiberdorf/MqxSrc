# IAR project web_hvac_twrk60f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../lib/twrk60f120m.iar/debug/usb; ../../../../lib/twrk60f120m.iar/debug/shell; ../../../../lib/twrk60f120m.iar/debug/rtcs; ../../../../lib/twrk60f120m.iar/debug/psp; ../../../../lib/twrk60f120m.iar/debug/mfs; ../../../../lib/twrk60f120m.iar/debug/bsp/Sources; ../../../../lib/twrk60f120m.iar/debug/bsp/Generated_Code; ../../../../lib/twrk60f120m.iar/debug/bsp; ../../../../lib/twrk60f120m.iar/debug; ../../../../demo/web_hvac
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60f120m.out
  ILINK.IlinkIcfFile: ../../../../lib/twrk60f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../lib/twrk60f120m.iar/release/usb; ../../../../lib/twrk60f120m.iar/release/shell; ../../../../lib/twrk60f120m.iar/release/rtcs; ../../../../lib/twrk60f120m.iar/release/psp; ../../../../lib/twrk60f120m.iar/release/mfs; ../../../../lib/twrk60f120m.iar/release/bsp/Sources; ../../../../lib/twrk60f120m.iar/release/bsp/Generated_Code; ../../../../lib/twrk60f120m.iar/release/bsp; ../../../../lib/twrk60f120m.iar/release; ../../../../demo/web_hvac
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../lib/twrk60f120m.iar/release/bsp/intflash.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../lib/twrk60f120m.iar/debug/bsp/ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../lib/twrk60f120m.iar/release/bsp/ram.icf
  group Source
    ../../../../demo/web_hvac/: HVAC_Private.h HVAC_Shell_Commands.c usb_classes.c USB_Task.c Logging_private.h cgi_hvac.c cgi_index.c HVAC.h USB_Task.h tfs_data.c HVAC_Util.c HVAC_Public.h Logging_public.h USB_File.h Command_Lists.c Shell_Task.c HVAC_Shell_Commands.h HVAC_IO.c HVAC_Task.c usb_classes.h Switch_Task.c cgi.h Logging_Task.c RTCS.c USB_File.c Tasks.c
  group MQX Libraries
    ../../../../lib/twrk60f120m.iar/debug/psp/: psp.a
    ../../../../lib/twrk60f120m.iar/release/shell/: shell.a
    ../../../../lib/twrk60f120m.iar/debug/rtcs/: rtcs.a
    ../../../../lib/twrk60f120m.iar/release/bsp/: bsp.a
    ../../../../lib/twrk60f120m.iar/debug/usb/: usbh.a
    ../../../../lib/twrk60f120m.iar/release/rtcs/: rtcs.a
    ../../../../lib/twrk60f120m.iar/debug/bsp/: bsp.a
    ../../../../lib/twrk60f120m.iar/release/mfs/: mfs.a
    ../../../../lib/twrk60f120m.iar/release/usb/: usbh.a
    ../../../../lib/twrk60f120m.iar/release/psp/: psp.a
    ../../../../lib/twrk60f120m.iar/debug/shell/: shell.a
    ../../../../lib/twrk60f120m.iar/debug/mfs/: mfs.a
