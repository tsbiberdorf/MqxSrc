# Keil uVision project mfs_twrk60f120m.uvproj, settings and files
target mfs_twrk60f120m Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: mfs (library)
  AfterMake: ../../../../mfs/build/bat/mfs_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/mfs uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\mfs_twrk60f120m_debug\mfs.lib ..\..\..\..\lib\twrk60f120m.uv4\debug\mfs\mfs.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/adc;../../../../mqx/source/io/lpm;../../../../mqx/source/io/serial;../../../../mqx/source/io/pcb;../../../../mqx/source/io/sai;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/pipe;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/tad;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/i2c/int;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/i2c;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/pccard;../../../../mqx/source/include;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/debug;../../../../mqx/source/bsp/twrk60f120m;../../../../mqx/source/io/timer;../../../../mqx/source/io/crc;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../config/twrk60f120m;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/gpio;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/nandflash/nfc;../../../../mqx/source/io/cm;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/rtc;../../../../mqx/source/io/tchres;../../../../mqx/source/io/enet;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m/core/M4;../../../../config/common;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/io_null;../../../../mqx/source/io/nandflash;../../../../mqx/source/io/usb;../../../../mqx/source/io/io_dun;../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/spi;../../../../mfs/source/include;../../../../mqx/source/io/tfs;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/flashx
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group MFS Source
    ../../../../mfs/source/generic/: mfs_rw.c mfs_create.c mfs_init.c mfs_data_sector.c mfs_fat.c dir_read.c mfs_delete.c mfs_read.c mfs_handle.c part_mgr.c mfs_directory.c mfs_open.c mfs_search.c mfs_dir_entry.c mfs_attribute.c mfs_write.c mfs_misc.c mfs_valdev.c mfs_format.c mfs_cluster.c mfs_time.c mfs_lfn.c mfs_parse.c mfs_rename.c
  group MFS Include
    ../../../../mfs/source/include/: mfs_rev.h part_mgr.h mfs_prv.h mfs_cnfg.h mfs.h
target mfs_twrk60f120m Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: mfs (library)
  AfterMake: ../../../../mfs/build/bat/mfs_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/mfs uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\mfs_twrk60f120m_release\mfs.lib ..\..\..\..\lib\twrk60f120m.uv4\release\mfs\mfs.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
