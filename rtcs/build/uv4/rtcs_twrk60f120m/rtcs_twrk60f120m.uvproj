# Keil uVision project rtcs_twrk60f120m.uvproj, settings and files
target rtcs_twrk60f120m Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: rtcs (library)
  AfterMake: ../../../../rtcs/build/bat/rtcs_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/rtcs uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\rtcs_twrk60f120m_debug\rtcs.lib ..\..\..\..\lib\twrk60f120m.uv4\debug\rtcs\rtcs.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/adc;../../../../mqx/source/io/lpm;../../../../mqx/source/io/serial;../../../../mqx/source/io/pcb;../../../../mqx/source/io/sai;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/pipe;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/tad;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/i2c/int;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/i2c;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/pccard;../../../../mqx/source/include;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/debug;../../../../rtcs/source/include;../../../../mqx/source/bsp/twrk60f120m;../../../../mqx/source/io/timer;../../../../mqx/source/io/crc;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../config/twrk60f120m;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/gpio;../../../../mqx/source/io/can/flexcan;../../../../rtcs/source/httpd;../../../../mqx/source/io/nandflash/nfc;../../../../mqx/source/io/cm;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/rtc;../../../../mqx/source/io/tchres;../../../../mqx/source/io/enet;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m/core/M4;../../../../config/common;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/io_null;../../../../mqx/source/io/nandflash;../../../../mqx/source/io/usb;../../../../mqx/source/io/io_dun;../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/spi;../../../../mfs/source/include;../../../../mqx/source/io/tfs;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/flashx
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group RTCS Source:tcpip
    ../../../../rtcs/source/tcpip/: tcpip.c rtcspcb.c ticker.c iptunnel.c checksum.c bootinit.c iproute.c bootcomm.c route.c tcp_rcv.c tcp_clos.c rip.c tcp_buf.c udp.c ip_reasm.c icmp.c ipif_add.c ipif_rem.c checksum6.c timer.c iplocal.c dhcpclnt.c iputil.c igmputil.c bootp.c dhcputil.c tcp.c igmp.c tcp_send.c ip.c ipradix.c
  group RTCS Include
    ../../../../rtcs/source/include/: icmp.h tcp_prv.h ip-e.h iptunnel.h ftpd_msg.h ipradix.h ftp.h ipcp.h ip6_prv.h ip.h arp_prv.h arpif.h socket.h lcp.h chap.h ppp_prv.h ip6_trace.h rtcsrtos.h rtcs_prv.h rtcsvers.h nat_prv.h ip_prv.h ip6_if.h ipcfg.h tcpip.h ccp.h pppfsm.h iwcfg.h natvers.h rtcshdlc.h pap.h ipc_udp.h nd6.h telnet.h md5.h snmp.h nat.h ipc_udp_prv.h tcp.h dhcpsrv.h rtcs_in.h checksum.h udp_prv.h ppp.h ip6.h select.h arp.h route.h ftpd.h asn1.h tftp.h fcs16.h icmp6.h dhcp.h ipcfg_prv.h rtcstime.h dns.h ppphdlc.h icmp6_prv.h rtcs.h ticker.h rtcscfg.h rtcs25x.h igmp.h addrinfo.h rtcspcb.h dhcpuprv.h rip_prv.h udp.h rtcslog.h dhcp_prv.h snmpcfg.h ftpc.h bootp.h rip.h nat_session.h icmp_prv.h
  group RTCS Source:if
    ../../../../rtcs/source/if/: rtcsglob.c ifstat.c dnsinit.c soigmp.c iftunnel.c ifdhcp.c soselall.c sosock.c sstream.c rtcsdela.c rtcslog1.c ifppp.c getnameinfo.c rtcsinit.c rtcsrand.c ifrem.c rtcscmd.c soip.c arpcmd.c ghbname.c ipcfg.c sosel1.c sdgram.c sockutil.c ifadd.c ping6.c inet_pton.c soudp.c inet_ntop.c rtcs.c ping.c iwcfg.c inet.c rtcshost.c dnsutil.c ifbootp.c ifdns.c solink.c rtcslog0.c select.c sosel0.c sotcp.c getaddrinfo.c ipcfg6.c iftraps.c soselset.c dnshosts.c
  group RTCS Source:nat
    ../../../../rtcs/source/nat/: ifdnat.c natevent.c natftp.c nat_apply.c nat.c natalg.c natdata.c nattftp.c ifnat.c dnat.c alggen.c sonat.c
  group RTCS Source:apps
    ../../../../rtcs/source/apps/: loadtb.c srecord.c ftpc.c telnsrv.c tftpacc.c tftp.c rtcsload.c sockio.c resolver.c telnetio.c telnet.c sntp.c ftpd_msg.c loadts.c binfile.c loadtc.c ftpd.c tftpsrv.c eds.c dhcpsrv.c ftpc_cmd.c coff.c echosrv.c rtcssh.c tftputil.c srec32.c ftpclnt.c ftpd_cmd.c
  group RTCS Source:ppp
    ../../../../rtcs/source/ppp/: lcp.c ccp.c lcpif.c pap.c hdlcio2.c genmd5.c md5step.c hdlcio.c ppphdlc.c pktrx.c md5.c ppp.c pkttx.c pppfsm.c chap.c gen16.c pppglob.c
  group RTCS Source:httpd
    ../../../../rtcs/source/httpd/: httpd_supp.h httpd_supp.c httpd_types.h httpd_poll.c httpd_cnfg.h httpd_prv.h httpd_task.c httpd.c httpd_wrapper.h httpd_mqx.h httpd.h
  group RTCS Source:media
    ../../../../rtcs/source/media/: ip-e.c arp.c ip6-e.c ipcp.c ipcpfsm.c proxyarp.c arpinit.c
  group RTCS Source:os
    ../../../../rtcs/source/os/mqx25x/: rtcsmsg.c rtcstask.c rtcssec.c rtcspart.c rtcsdate.c rtcsmsec.c
  group RTCS Source:snmp
    ../../../../rtcs/source/snmp/: mib.c snmp.c 1213.c mqxmib.c trap_receivers.c traps.c
target rtcs_twrk60f120m Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: rtcs (library)
  AfterMake: ../../../../rtcs/build/bat/rtcs_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/rtcs uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\rtcs_twrk60f120m_release\rtcs.lib ..\..\..\..\lib\twrk60f120m.uv4\release\rtcs\rtcs.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
