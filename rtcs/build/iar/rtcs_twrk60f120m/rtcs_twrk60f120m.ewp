# IAR project rtcs_twrk60f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../rtcs/source/include; ../../../../rtcs/source/httpd; ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_dun; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/crc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/include; ../../../../mqx/source/bsp/twrk60f120m; ../../../../mfs/source/include; ../../../../config/twrk60f120m; ../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../rtcs/build/bat/rtcs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/rtcs" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../rtcs/build/bat/rtcs_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/rtcs" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group RTCS Source/tcpip
    ../../../../rtcs/source/tcpip/: ipif_rem.c bootcomm.c ip_reasm.c iputil.c ip.c iplocal.c timer.c tcp_rcv.c tcp.c igmp.c igmputil.c iptunnel.c icmp.c ticker.c route.c dhcpclnt.c rip.c tcp_clos.c bootp.c iproute.c udp.c bootinit.c tcp_buf.c checksum.c dhcputil.c tcpip.c ipradix.c tcp_send.c ipif_add.c rtcspcb.c checksum6.c
  group RTCS Source/apps
    ../../../../rtcs/source/apps/: ftpd.c sntp.c telnetio.c ftpd_msg.c srec32.c rtcsload.c ftpc.c rtcssh.c telnsrv.c sockio.c tftputil.c ftpclnt.c echosrv.c loadts.c resolver.c coff.c ftpd_cmd.c telnet.c srecord.c tftpacc.c loadtb.c dhcpsrv.c tftpsrv.c ftpc_cmd.c loadtc.c binfile.c tftp.c eds.c
  group RTCS Source/if
    ../../../../rtcs/source/if/: sosock.c rtcscmd.c ipcfg.c rtcshost.c ping6.c sotcp.c dnsutil.c ifrem.c dnshosts.c ghbname.c rtcslog0.c arpcmd.c ping.c getnameinfo.c ifadd.c soudp.c sosel0.c soselset.c getaddrinfo.c inet_ntop.c rtcs.c select.c sstream.c ifppp.c ipcfg6.c rtcsinit.c sockutil.c iwcfg.c iftunnel.c sosel1.c soip.c solink.c rtcsrand.c soselall.c inet.c rtcsglob.c ifstat.c soigmp.c rtcslog1.c ifdns.c inet_pton.c ifdhcp.c iftraps.c sdgram.c dnsinit.c rtcsdela.c ifbootp.c
  group RTCS Source/httpd
    ../../../../rtcs/source/httpd/: httpd_poll.c httpd_supp.c httpd.h httpd_prv.h httpd.c httpd_cnfg.h httpd_task.c httpd_supp.h httpd_wrapper.h httpd_mqx.h httpd_types.h
  group RTCS Source/nat
    ../../../../rtcs/source/nat/: nat.c natevent.c sonat.c ifdnat.c natdata.c dnat.c natalg.c ifnat.c natftp.c nat_apply.c nattftp.c alggen.c
  group RTCS Source/ppp
    ../../../../rtcs/source/ppp/: pktrx.c gen16.c md5.c ccp.c pppfsm.c chap.c ppphdlc.c lcpif.c genmd5.c ppp.c hdlcio2.c pppglob.c hdlcio.c pap.c md5step.c lcp.c pkttx.c
  group RTCS Source/os
    ../../../../rtcs/source/os/mqx25x/: rtcsmsg.c rtcstask.c rtcspart.c rtcsmsec.c rtcssec.c rtcsdate.c
  group RTCS Source/media
    ../../../../rtcs/source/media/: ipcpfsm.c arp.c ip6-e.c ipcp.c arpinit.c proxyarp.c ip-e.c
  group RTCS Source/snmp
    ../../../../rtcs/source/snmp/: mqxmib.c 1213.c snmp.c trap_receivers.c traps.c mib.c
  group RTCS Include
    ../../../../rtcs/source/include/: chap.h arp.h ip6_if.h ccp.h rtcslog.h ip_prv.h ipcfg.h dhcp.h rip_prv.h natvers.h icmp6.h rtcstime.h rtcs_in.h socket.h tcpip.h dhcp_prv.h icmp6_prv.h ip6_trace.h pppfsm.h ipc_udp.h dns.h rtcs_prv.h telnet.h pap.h igmp.h rip.h fcs16.h rtcs25x.h asn1.h ip.h icmp.h ipcp.h snmp.h lcp.h md5.h icmp_prv.h rtcspcb.h ipc_udp_prv.h udp_prv.h rtcsrtos.h ftpd.h checksum.h nd6.h tcp.h tftp.h rtcs.h nat.h arpif.h addrinfo.h snmpcfg.h udp.h nat_session.h rtcscfg.h ip6_prv.h ppp_prv.h ip-e.h iptunnel.h ftpc.h dhcpsrv.h iwcfg.h route.h ipcfg_prv.h dhcpuprv.h arp_prv.h ftp.h tcp_prv.h ipradix.h nat_prv.h ip6.h bootp.h ppp.h select.h ticker.h rtcshdlc.h rtcsvers.h ppphdlc.h ftpd_msg.h
