# IAR project snmp_twrvf65gs10_m4.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_M4 Freescale VF6xx_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/snmp; ../../../../../lib/twrvf65gs10_m4.iar/debug/rtcs; ../../../../../lib/twrvf65gs10_m4.iar/debug/psp; ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/Sources; ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/Generated_Code; ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp; ../../../../../lib/twrvf65gs10_m4.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_m4.bin
  ILINK.IlinkOutputFile: twrvf65gs10_m4.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/ram.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __boot
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/snmp; ../../../../../lib/twrvf65gs10_m4.iar/release/rtcs; ../../../../../lib/twrvf65gs10_m4.iar/release/psp; ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/Sources; ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/Generated_Code; ../../../../../lib/twrvf65gs10_m4.iar/release/bsp; ../../../../../lib/twrvf65gs10_m4.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/ram.icf
  group Source
    ../../../../../rtcs/examples/snmp/: config.h snmp_demo.c snmp_demo.h snmptraps.c
  group MQX Libraries
    ../../../../../lib/twrvf65gs10_m4.iar/release/bsp/: bsp.a
    ../../../../../lib/twrvf65gs10_m4.iar/release/psp/: psp.a
    ../../../../../lib/twrvf65gs10_m4.iar/release/rtcs/: rtcs.a
    ../../../../../lib/twrvf65gs10_m4.iar/debug/rtcs/: rtcs.a
    ../../../../../lib/twrvf65gs10_m4.iar/debug/psp/: psp.a
    ../../../../../lib/twrvf65gs10_m4.iar/debug/bsp/: bsp.a
