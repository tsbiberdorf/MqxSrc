# IAR project snmp_twrvf65gs10_a5.ewp, settings and files
configuration DDR Debug (ARM, debug)
  General.OGChipSelectEditMenu: VF6xx_A5 Freescale VF6xx_A5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/snmp; ../../../../../lib/twrvf65gs10_a5.iar/debug/rtcs; ../../../../../lib/twrvf65gs10_a5.iar/debug/psp; ../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Sources; ../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/Generated_Code; ../../../../../lib/twrvf65gs10_a5.iar/debug/bsp; ../../../../../lib/twrvf65gs10_a5.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrvf65gs10_a5.bin
  ILINK.IlinkOutputFile: twrvf65gs10_a5.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/ddr.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __boot
configuration DDR Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/snmp; ../../../../../lib/twrvf65gs10_a5.iar/release/rtcs; ../../../../../lib/twrvf65gs10_a5.iar/release/psp; ../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Sources; ../../../../../lib/twrvf65gs10_a5.iar/release/bsp/Generated_Code; ../../../../../lib/twrvf65gs10_a5.iar/release/bsp; ../../../../../lib/twrvf65gs10_a5.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_a5.iar/release/bsp/ddr.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/intram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrvf65gs10_a5.iar/release/bsp/intram.icf
  group Source
    ../../../../../rtcs/examples/snmp/: config.h snmp_demo.c snmp_demo.h snmptraps.c
  group MQX Libraries
    ../../../../../lib/twrvf65gs10_a5.iar/release/psp/: psp.a
    ../../../../../lib/twrvf65gs10_a5.iar/release/rtcs/: rtcs.a
    ../../../../../lib/twrvf65gs10_a5.iar/debug/psp/: psp.a
    ../../../../../lib/twrvf65gs10_a5.iar/release/bsp/: bsp.a
    ../../../../../lib/twrvf65gs10_a5.iar/debug/rtcs/: rtcs.a
    ../../../../../lib/twrvf65gs10_a5.iar/debug/bsp/: bsp.a
