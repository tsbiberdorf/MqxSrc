# IAR project snmp_twrk53n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK53DN512Zxxx10 Freescale MK53DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/snmp; ../../../../../lib/twrk53n512.iar/debug/rtcs; ../../../../../lib/twrk53n512.iar/debug/psp; ../../../../../lib/twrk53n512.iar/debug/bsp/Sources; ../../../../../lib/twrk53n512.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk53n512.iar/debug/bsp; ../../../../../lib/twrk53n512.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk53n512.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk53n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../../rtcs/examples/snmp; ../../../../../lib/twrk53n512.iar/release/rtcs; ../../../../../lib/twrk53n512.iar/release/psp; ../../../../../lib/twrk53n512.iar/release/bsp/Sources; ../../../../../lib/twrk53n512.iar/release/bsp/Generated_Code; ../../../../../lib/twrk53n512.iar/release/bsp; ../../../../../lib/twrk53n512.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrk53n512.iar/release/bsp/intflash.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../lib/twrk53n512.iar/debug/bsp/ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrk53n512.iar/release/bsp/ram.icf
  group Source
    ../../../../../rtcs/examples/snmp/: config.h snmp_demo.c snmp_demo.h snmptraps.c
  group MQX Libraries
    ../../../../../lib/twrk53n512.iar/release/bsp/: bsp.a
    ../../../../../lib/twrk53n512.iar/release/rtcs/: rtcs.a
    ../../../../../lib/twrk53n512.iar/release/psp/: psp.a
    ../../../../../lib/twrk53n512.iar/debug/bsp/: bsp.a
    ../../../../../lib/twrk53n512.iar/debug/rtcs/: rtcs.a
    ../../../../../lib/twrk53n512.iar/debug/psp/: psp.a
