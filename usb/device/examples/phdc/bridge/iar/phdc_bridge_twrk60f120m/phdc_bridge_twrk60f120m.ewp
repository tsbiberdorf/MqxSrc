# IAR project phdc_bridge_twrk60f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../usb/device/examples/phdc/bridge; ../../../../../../../lib/twrk60f120m.iar/debug/usb; ../../../../../../../lib/twrk60f120m.iar/debug/rtcs; ../../../../../../../lib/twrk60f120m.iar/debug/psp; ../../../../../../../lib/twrk60f120m.iar/debug/bsp/Sources; ../../../../../../../lib/twrk60f120m.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrk60f120m.iar/debug/bsp; ../../../../../../../lib/twrk60f120m.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60f120m.out
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../../../usb/device/examples/phdc/bridge; ../../../../../../../lib/twrk60f120m.iar/release/usb; ../../../../../../../lib/twrk60f120m.iar/release/rtcs; ../../../../../../../lib/twrk60f120m.iar/release/psp; ../../../../../../../lib/twrk60f120m.iar/release/bsp/Sources; ../../../../../../../lib/twrk60f120m.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrk60f120m.iar/release/bsp; ../../../../../../../lib/twrk60f120m.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60f120m.iar/release/bsp/intflash.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60f120m.iar/debug/bsp/ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60f120m.iar/release/bsp/ram.icf
  group Source
    ../../../../../../../usb/device/examples/phdc/bridge/: bridge.c phdc_server.h bridge.h usb_descriptor.c phdc_server.c usb_descriptor.h ieee11073_nom_codes.h ieee11073_phd_types.h
  group MQX Libraries
    ../../../../../../../lib/twrk60f120m.iar/debug/usb/: usbd.a
    ../../../../../../../lib/twrk60f120m.iar/debug/rtcs/: rtcs.a
    ../../../../../../../lib/twrk60f120m.iar/release/usb/: usbd.a
    ../../../../../../../lib/twrk60f120m.iar/release/rtcs/: rtcs.a
    ../../../../../../../lib/twrk60f120m.iar/debug/bsp/: bsp.a
    ../../../../../../../lib/twrk60f120m.iar/debug/psp/: psp.a
    ../../../../../../../lib/twrk60f120m.iar/release/bsp/: bsp.a
    ../../../../../../../lib/twrk60f120m.iar/release/psp/: psp.a
