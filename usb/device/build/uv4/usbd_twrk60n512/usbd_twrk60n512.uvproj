# Keil uVision project usbd_twrk60n512.uvproj, settings and files
target usbd_twrk60n512 Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: usbd (library)
  AfterMake: ../../../../../usb/device/build/bat/usbd_twrk60n512.bat ../../../../.. ../../../../../lib/twrk60n512.uv4/debug/usb uv4
  AfterMake: ../../../../../mqx/build/bat/keil.bat .\usbd_twrk60n512_debug\usbd.lib ..\..\..\..\..\lib\twrk60n512.uv4\debug\usb\usbd.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../../mqx/source/io/i2c/polled;../../../../../mqx/source/io/usb;../../../../../mqx/source/psp/cortex_m;../../../../../mqx/source/io/pipe;../../../../../mqx/source/io/flashx;../../../../../mqx/source/io/gpio/kgpio;../../../../../usb/device/source/classes/include;../../../../../mqx/source/io/i2c/int;../../../../../usb/host/source/host/khci;../../../../../mqx/source/io/hmi;../../../../../mqx/source/bsp/twrk60n512;../../../../../mqx/source/io/io_mem;../../../../../mqx/source/io/enet/phy;../../../../../mqx/source/io/timer;../../../../../mqx/source/io/tfs;../../../../../usb/device/source/include/khci;../../../../../mqx/source/io/sdcard/sdcard_spi;../../../../../usb/common/include;../../../../../mqx/source/io/enet;../../../../../mqx/source/io/adc/kadc;../../../../../mqx/source/io/hmi/TSS/shared;../../../../../mqx/source/io/can/flexcan;../../../../../mqx/source/io/hwtimer;../../../../../mqx/source/io/rtc;../../../../../mqx/source/io/lwgpio;../../../../../mqx/source/io/tchres;../../../../../mqx/source/io/serial;../../../../../config/common;../../../../../mqx/source/io/io_dun;../../../../../mqx/source/psp/cortex_m/cpu;../../../../../mqx/source/io/pcflash;../../../../../mqx/source/io/i2c;../../../../../config/twrk60n512;../../../../../usb/device/source/include;../../../../../mqx/source/io/i2s/int;../../../../../mqx/source/io/cm;../../../../../mqx/source/io/gpio;../../../../../mqx/source/io/pcb;../../../../../mqx/source/io/sdcard;../../../../../mqx/source/io/enet/macnet;../../../../../mqx/source/io/pcb/mqxa;../../../../../mqx/source/io/esdhc;../../../../../mqx/source/io/lpm;../../../../../mqx/source/io/pccard;../../../../../mqx/source/io/i2s;../../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../../mqx/source/io/flashx/freescale;../../../../../mqx/source/io/adc;../../../../../mqx/source/tad;../../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../../mqx/source/io/spi;../../../../../mqx/source/io/debug;../../../../../mqx/source/include;../../../../../mqx/source/psp/cortex_m/core/M4;../../../../../usb/device/source/include/rtos;../../../../../mqx/source/io/io_null
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
  group USB Low Level Driver:khci
    ../../../../../usb/device/source/device/khci/: khci_dev_main.c callback_khci.c
    ../../../../../usb/device/source/include/khci/: khci_usbprv.h khci_dev_main.h
    ../../../../../usb/host/source/host/khci/: khci_prv.h
  group USB Device:source
    ../../../../../usb/device/source/device/: dev_utl.c dev_shut.c dev_send.c dev_cncl.c dev_recv.c dev_main.c dev_ep_deinit.c
  group USB Device:os
    ../../../../../usb/device/source/include/rtos/: mqx_dev.h
  group USB Device:include
    ../../../../../usb/common/include/: usb_misc.h usb_desc.h usb_misc_prv.h usb_debug.h usb_error.h usb_types.h usb_prv.h usb.h
    ../../../../../usb/device/source/include/: dev_main.h devapi.h dev_cnfg.h
    ../../../../../usb/device/source/classes/include/: usb_stack_config.h
  group USB Class Drivers:cdc
    ../../../../../usb/device/source/classes/include/: usb_cdc_pstn.h usb_cdc.h
    ../../../../../usb/device/source/classes/cdc/: usb_cdc.c usb_cdc_pstn.c
  group USB Class Drivers:msd
    ../../../../../usb/device/source/classes/msd/: usb_msc.c usb_msc_scsi.c
    ../../../../../usb/device/source/classes/include/: usb_msc.h usb_msc_scsi.h
  group USB Class Drivers:framework
    ../../../../../usb/device/source/classes/include/: usb_framework.h
    ../../../../../usb/device/source/classes/common/: usb_framework.c
  group USB Class Drivers:hid
    ../../../../../usb/device/source/classes/include/: usb_hid.h
    ../../../../../usb/device/source/classes/hid/: usb_hid.c
  group USB Class Drivers:usb_class
    ../../../../../usb/device/source/classes/common/: usb_class.c
    ../../../../../usb/device/source/classes/include/: usb_class.h
  group USB Class Drivers:audio
    ../../../../../usb/device/source/classes/include/: usb_audio.h
    ../../../../../usb/device/source/classes/audio/: usb_audio.c
  group USB Class Drivers:phdc
    ../../../../../usb/device/source/classes/include/: usb_phdc.h
    ../../../../../usb/device/source/classes/phdc/: usb_phdc.c
target usbd_twrk60n512 Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: usbd (library)
  AfterMake: ../../../../../usb/device/build/bat/usbd_twrk60n512.bat ../../../../.. ../../../../../lib/twrk60n512.uv4/release/usb uv4
  AfterMake: ../../../../../mqx/build/bat/keil.bat .\usbd_twrk60n512_release\usbd.lib ..\..\..\..\..\lib\twrk60n512.uv4\release\usb\usbd.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
