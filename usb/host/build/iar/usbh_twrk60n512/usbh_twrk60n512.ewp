# IAR project usbh_twrk60n512.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../../usb/host/source/rtos/mqx; ../../../../../usb/host/source/include; ../../../../../usb/host/source/host/khci; ../../../../../usb/host/source/classes/printer; ../../../../../usb/host/source/classes/phdc; ../../../../../usb/host/source/classes/msd/mfs; ../../../../../usb/host/source/classes/msd; ../../../../../usb/host/source/classes/hub; ../../../../../usb/host/source/classes/hid; ../../../../../usb/host/source/classes/cdc; ../../../../../usb/host/source/classes/audio; ../../../../../usb/common/include; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/tchres; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_dun; ../../../../../mqx/source/io/i2s/int; ../../../../../mqx/source/io/i2s; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/hmi/TSS/shared; ../../../../../mqx/source/io/hmi; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/esdhc; ../../../../../mqx/source/io/enet/phy; ../../../../../mqx/source/io/enet/macnet; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/cm; ../../../../../mqx/source/io/can/flexcan; ../../../../../mqx/source/io/adc/kadc; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/include; ../../../../../mqx/source/bsp/twrk60n512; ../../../../../config/twrk60n512; ../../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../../usb/host/build/bat/usbh_twrk60n512.bat" "../../../../.." "../../../../../lib/twrk60n512.iar/debug/usb" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../../usb/host/build/bat/usbh_twrk60n512.bat" "../../../../.." "../../../../../lib/twrk60n512.iar/release/usb" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group USB Class Drivers/msd
    ../../../../../usb/host/source/classes/msd/mfs/: usbmfs.h usbmfspr.h usbmfs.c
    ../../../../../usb/host/source/classes/msd/: usb_host_msd_bo.c usb_host_msd_bo.h usb_host_msd_queue.c usb_host_msd_ufi.c usb_host_msd_ufi.h
  group USB Class Drivers/hub
    ../../../../../usb/host/source/classes/hub/: usb_host_hub_sm.c usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.h
  group USB Class Drivers/cdc
    ../../../../../usb/host/source/classes/cdc/: usb_host_cdc.h usb_host_cdc_intf.c usb_host_cdc.c
  group USB Class Drivers/audio
    ../../../../../usb/host/source/classes/audio/: usb_host_audio.c usb_host_audio_intf.c usb_host_audio.h
  group USB Class Drivers/printer
    ../../../../../usb/host/source/classes/printer/: usb_host_printer.c usb_host_printer.h
  group USB Class Drivers/phdc
    ../../../../../usb/host/source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers/hid
    ../../../../../usb/host/source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Host/include
    ../../../../../usb/host/source/include/: host_dev_list.h host_cnfg.h host_ch9.h host_snd.h host_shut.h host_common.h host_close.h host_cnl.h host_rcv.h host_main.h hostapi.h
    ../../../../../usb/common/include/: usb_types.h usb.h usb_misc.h usb_desc.h usb_misc_prv.h usb_debug.h usb_prv.h usb_error.h
  group USB Host/source
    ../../../../../usb/host/source/host/: host_shut.c host_snd.c host_cnl.c host_common.c host_close.c host_ch9.c host_dev_list.c host_main.c host_rcv.c
  group USB Host/os
    ../../../../../usb/host/source/rtos/mqx/: mqx_dll.h usb_mqx.c mqx_host.h usb_mqx.h mqx_dll.c
  group USB Low Level Driver/khci
    ../../../../../usb/host/source/host/khci/: khci.h khci.c
