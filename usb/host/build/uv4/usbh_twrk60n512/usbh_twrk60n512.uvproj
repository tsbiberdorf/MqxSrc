# Keil uVision project usbh_twrk60n512.uvproj, settings and files
target usbh_twrk60n512 Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: usbh (library)
  AfterMake: ../../../../../usb/host/build/bat/usbh_twrk60n512.bat ../../../../.. ../../../../../lib/twrk60n512.uv4/debug/usb uv4
  AfterMake: ../../../../../mqx/build/bat/keil.bat .\usbh_twrk60n512_debug\usbh.lib ..\..\..\..\..\lib\twrk60n512.uv4\debug\usb\usbh.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../../mqx/source/io/i2c/polled;../../../../../mqx/source/io/usb;../../../../../mqx/source/psp/cortex_m;../../../../../mqx/source/io/pipe;../../../../../mqx/source/io/flashx;../../../../../mqx/source/io/gpio/kgpio;../../../../../usb/host/source/classes/phdc;../../../../../mqx/source/io/i2c/int;../../../../../usb/host/source/classes/printer;../../../../../usb/host/source/classes/msd/mfs;../../../../../usb/host/source/classes/msd;../../../../../usb/host/source/host/khci;../../../../../usb/host/source/classes/cdc;../../../../../mqx/source/io/hmi;../../../../../mqx/source/bsp/twrk60n512;../../../../../mqx/source/io/io_mem;../../../../../mqx/source/io/enet/phy;../../../../../mqx/source/io/timer;../../../../../mqx/source/io/tfs;../../../../../mqx/source/io/sdcard/sdcard_spi;../../../../../usb/common/include;../../../../../mqx/source/io/enet;../../../../../mqx/source/io/adc/kadc;../../../../../mqx/source/io/hmi/TSS/shared;../../../../../mqx/source/io/can/flexcan;../../../../../mqx/source/io/hwtimer;../../../../../mqx/source/io/rtc;../../../../../usb/host/source/classes/audio;../../../../../usb/host/source/classes/hub;../../../../../mqx/source/io/lwgpio;../../../../../mqx/source/io/tchres;../../../../../mqx/source/io/serial;../../../../../config/common;../../../../../mqx/source/io/io_dun;../../../../../mqx/source/psp/cortex_m/cpu;../../../../../mqx/source/io/pcflash;../../../../../mqx/source/io/i2c;../../../../../config/twrk60n512;../../../../../mqx/source/io/i2s/int;../../../../../mqx/source/io/cm;../../../../../mqx/source/io/gpio;../../../../../mqx/source/io/pcb;../../../../../mqx/source/io/sdcard;../../../../../mqx/source/io/enet/macnet;../../../../../mqx/source/io/pcb/mqxa;../../../../../mqx/source/io/esdhc;../../../../../mqx/source/io/lpm;../../../../../usb/host/source/include;../../../../../mqx/source/io/pccard;../../../../../mqx/source/io/i2s;../../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../../mqx/source/io/flashx/freescale;../../../../../mqx/source/io/adc;../../../../../mqx/source/tad;../../../../../usb/host/source/classes/hid;../../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../../mqx/source/io/spi;../../../../../usb/host/source/rtos/mqx;../../../../../mqx/source/io/debug;../../../../../mqx/source/include;../../../../../mqx/source/psp/cortex_m/core/M4;../../../../../mqx/source/io/io_null
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
  group USB Host:include
    ../../../../../usb/host/source/include/: hostapi.h host_common.h host_ch9.h host_rcv.h host_shut.h host_snd.h host_close.h host_main.h host_dev_list.h host_cnl.h host_cnfg.h
    ../../../../../usb/common/include/: usb_misc.h usb_desc.h usb_misc_prv.h usb_debug.h usb_error.h usb_types.h usb_prv.h usb.h
  group USB Host:os
    ../../../../../usb/host/source/rtos/mqx/: usb_mqx.h mqx_dll.c mqx_dll.h mqx_host.h usb_mqx.c
  group USB Class Drivers:msd
    ../../../../../usb/host/source/classes/msd/: usb_host_msd_ufi.h usb_host_msd_queue.c usb_host_msd_bo.h usb_host_msd_bo.c usb_host_msd_ufi.c
    ../../../../../usb/host/source/classes/msd/mfs/: usbmfs.h usbmfs.c usbmfspr.h
  group USB Host:source
    ../../../../../usb/host/source/host/: host_shut.c host_rcv.c host_snd.c host_common.c host_dev_list.c host_cnl.c host_main.c host_ch9.c host_close.c
  group USB Low Level Driver:khci
    ../../../../../usb/host/source/host/khci/: khci.h khci.c
  group USB Class Drivers:hub
    ../../../../../usb/host/source/classes/hub/: usb_host_hub.h usb_host_hub.c usb_host_hub_sm.c usb_host_hub_sm.h usb_host_hub_prv.h
  group USB Class Drivers:cdc
    ../../../../../usb/host/source/classes/cdc/: usb_host_cdc_intf.c usb_host_cdc.c usb_host_cdc.h
  group USB Class Drivers:printer
    ../../../../../usb/host/source/classes/printer/: usb_host_printer.h usb_host_printer.c
  group USB Class Drivers:audio
    ../../../../../usb/host/source/classes/audio/: usb_host_audio.h usb_host_audio.c usb_host_audio_intf.c
  group USB Class Drivers:hid
    ../../../../../usb/host/source/classes/hid/: usb_host_hid.h usb_host_hid.c
  group USB Class Drivers:phdc
    ../../../../../usb/host/source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
target usbh_twrk60n512 Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: usbh (library)
  AfterMake: ../../../../../usb/host/build/bat/usbh_twrk60n512.bat ../../../../.. ../../../../../lib/twrk60n512.uv4/release/usb uv4
  AfterMake: ../../../../../mqx/build/bat/keil.bat .\usbh_twrk60n512_release\usbh.lib ..\..\..\..\..\lib\twrk60n512.uv4\release\usb\usbh.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
