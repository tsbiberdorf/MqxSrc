# Keil uVision project usbh_twrk60f120m.uvproj, settings and files
target usbh_twrk60f120m Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: usbh (library)
  AfterMake: ../../../../../usb/host/build/bat/usbh_twrk60f120m.bat ../../../../.. ../../../../../lib/twrk60f120m.uv4/debug/usb uv4
  AfterMake: ../../../../../mqx/build/bat/keil.bat .\usbh_twrk60f120m_debug\usbh.lib ..\..\..\..\..\lib\twrk60f120m.uv4\debug\usb\usbh.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../../mqx/source/io/pipe;../../../../../usb/host/source/classes/printer;../../../../../usb/host/source/classes/msd/mfs;../../../../../mqx/source/io/nandflash;../../../../../usb/host/source/host/khci;../../../../../mqx/source/bsp/twrk60f120m;../../../../../usb/host/source/classes/cdc;../../../../../mqx/source/io/timer;../../../../../mqx/source/io/tfs;../../../../../usb/common/include;../../../../../mqx/source/io/enet;../../../../../mqx/source/io/can/flexcan;../../../../../mqx/source/io/rtc;../../../../../config/twrk60f120m;../../../../../usb/host/source/classes/hub;../../../../../mqx/source/io/serial;../../../../../config/common;../../../../../mqx/source/io/io_dun;../../../../../mqx/source/psp/cortex_m/cpu;../../../../../mqx/source/io/pcflash;../../../../../usb/host/source/host/ehci;../../../../../mqx/source/io/sai/int;../../../../../mqx/source/io/gpio;../../../../../mqx/source/io/enet/macnet;../../../../../mqx/source/io/pcb/mqxa;../../../../../mqx/source/io/esdhc;../../../../../mqx/source/io/lpm;../../../../../mqx/source/io/usb_dcd/polled;../../../../../mqx/source/io/pccard;../../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../../usb/host/source/classes/hid;../../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../../usb/host/source/rtos/mqx;../../../../../mqx/source/include;../../../../../mqx/source/psp/cortex_m/core/M4;../../../../../mqx/source/io/usb;../../../../../mqx/source/io/i2c/polled;../../../../../mqx/source/io/gpio/kgpio;../../../../../mqx/source/io/flashx;../../../../../mqx/source/psp/cortex_m;../../../../../mqx/source/io/crc;../../../../../usb/host/source/classes/phdc;../../../../../mqx/source/io/usb_dcd;../../../../../mqx/source/io/i2c/int;../../../../../usb/host/source/classes/msd;../../../../../mqx/source/io/io_mem;../../../../../mqx/source/io/enet/phy;../../../../../mqx/source/io/nandflash/nfc;../../../../../mqx/source/io/sdcard/sdcard_spi;../../../../../mqx/source/io/adc/kadc;../../../../../mqx/source/io/hwtimer;../../../../../usb/host/source/classes/audio;../../../../../mqx/source/io/tchres;../../../../../mqx/source/io/lwgpio;../../../../../mqx/source/io/i2c;../../../../../mqx/source/io/sdcard;../../../../../mqx/source/io/pcb;../../../../../mqx/source/io/cm;../../../../../mqx/source/io/sai;../../../../../usb/host/source/include;../../../../../mqx/source/io/usb_dcd/int;../../../../../mqx/source/io/flashx/freescale;../../../../../mqx/source/io/adc;../../../../../mqx/source/tad;../../../../../mqx/source/io/spi;../../../../../mqx/source/io/debug;../../../../../mqx/source/io/io_null
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group USB Host:include
    ../../../../../usb/host/source/include/: hostapi.h host_shut.h host_close.h host_main.h host_dev_list.h host_cnl.h host_ch9.h host_common.h host_rcv.h host_snd.h host_cnfg.h
    ../../../../../usb/common/include/: usb_desc.h usb_misc_prv.h usb_error.h usb_misc.h usb_debug.h usb_prv.h usb_types.h usb.h
  group USB Host:os
    ../../../../../usb/host/source/rtos/mqx/: usb_mqx.h usb_mqx.c mqx_dll.c mqx_dll.h mqx_host.h
  group USB Low Level Driver:ehci
    ../../../../../usb/host/source/host/ehci/: ehci_cncl.c ehci_intr.h ehci_utl.c ehci_bw.c ehci_iso.h ehci_utl.h ehci_shut.h ehci_cache.h ehci.h ehci_cncl.h ehci_main.c ehci_main.h ehci_iso.c ehci_shut.c ehci_bw.h ehci_intr.c
  group USB Class Drivers:cdc
    ../../../../../usb/host/source/classes/cdc/: usb_host_cdc_intf.c usb_host_cdc.c usb_host_cdc.h
  group USB Class Drivers:printer
    ../../../../../usb/host/source/classes/printer/: usb_host_printer.h usb_host_printer.c
  group USB Class Drivers:msd
    ../../../../../usb/host/source/classes/msd/mfs/: usbmfs.h usbmfs.c usbmfspr.h
    ../../../../../usb/host/source/classes/msd/: usb_host_msd_ufi.c usb_host_msd_ufi.h usb_host_msd_queue.c usb_host_msd_bo.h usb_host_msd_bo.c
  group USB Class Drivers:audio
    ../../../../../usb/host/source/classes/audio/: usb_host_audio.h usb_host_audio.c usb_host_audio_intf.c
  group USB Host:source
    ../../../../../usb/host/source/host/: host_snd.c host_common.c host_main.c host_close.c host_shut.c host_rcv.c host_dev_list.c host_cnl.c host_ch9.c
  group USB Class Drivers:hub
    ../../../../../usb/host/source/classes/hub/: usb_host_hub_sm.h usb_host_hub_prv.h usb_host_hub.h usb_host_hub.c usb_host_hub_sm.c
  group USB Class Drivers:phdc
    ../../../../../usb/host/source/classes/phdc/: usb_host_phdc.c usb_host_phdc.h
  group USB Class Drivers:hid
    ../../../../../usb/host/source/classes/hid/: usb_host_hid.c usb_host_hid.h
  group USB Low Level Driver:khci
    ../../../../../usb/host/source/host/khci/: khci.h khci.c
target usbh_twrk60f120m Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: usbh (library)
  AfterMake: ../../../../../usb/host/build/bat/usbh_twrk60f120m.bat ../../../../.. ../../../../../lib/twrk60f120m.uv4/release/usb uv4
  AfterMake: ../../../../../mqx/build/bat/keil.bat .\usbh_twrk60f120m_release\usbh.lib ..\..\..\..\..\lib\twrk60f120m.uv4\release\usb\usbh.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
