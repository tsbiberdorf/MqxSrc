# IAR project speaker_host_twrk60d100m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../../../usb/host/examples/audio/speaker; ../../../../../../../lib/twrk60d100m.iar/debug/usb; ../../../../../../../lib/twrk60d100m.iar/debug/shell; ../../../../../../../lib/twrk60d100m.iar/debug/psp; ../../../../../../../lib/twrk60d100m.iar/debug/mfs; ../../../../../../../lib/twrk60d100m.iar/debug/bsp/Sources; ../../../../../../../lib/twrk60d100m.iar/debug/bsp/Generated_Code; ../../../../../../../lib/twrk60d100m.iar/debug/bsp; ../../../../../../../lib/twrk60d100m.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60d100m.out
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60d100m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../../../usb/host/examples/audio/speaker; ../../../../../../../lib/twrk60d100m.iar/release/usb; ../../../../../../../lib/twrk60d100m.iar/release/shell; ../../../../../../../lib/twrk60d100m.iar/release/psp; ../../../../../../../lib/twrk60d100m.iar/release/mfs; ../../../../../../../lib/twrk60d100m.iar/release/bsp/Sources; ../../../../../../../lib/twrk60d100m.iar/release/bsp/Generated_Code; ../../../../../../../lib/twrk60d100m.iar/release/bsp; ../../../../../../../lib/twrk60d100m.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60d100m.iar/release/bsp/intflash.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60d100m.iar/debug/bsp/ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../lib/twrk60d100m.iar/release/bsp/ram.icf
  group Source
    ../../../../../../../usb/host/examples/audio/speaker/: audio_speaker.c hidkeyboard.h hidkeyboard.c sh_audio.c audio_speaker.h usb_classes.c sh_audio.h wav.c sd_card.c main.c wav.h usb_classes.h sd_card.h
  group MQX Libraries
    ../../../../../../../lib/twrk60d100m.iar/debug/mfs/: mfs.a
    ../../../../../../../lib/twrk60d100m.iar/debug/shell/: shell.a
    ../../../../../../../lib/twrk60d100m.iar/debug/bsp/: bsp.a
    ../../../../../../../lib/twrk60d100m.iar/release/shell/: shell.a
    ../../../../../../../lib/twrk60d100m.iar/release/mfs/: mfs.a
    ../../../../../../../lib/twrk60d100m.iar/debug/psp/: psp.a
    ../../../../../../../lib/twrk60d100m.iar/release/psp/: psp.a
    ../../../../../../../lib/twrk60d100m.iar/debug/usb/: usbh.a
    ../../../../../../../lib/twrk60d100m.iar/release/usb/: usbh.a
    ../../../../../../../lib/twrk60d100m.iar/release/bsp/: bsp.a
