# Keil uVision project speaker_host_twrk60d100m.uvproj, settings and files
target speaker_host Int Flash Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: speaker_host +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../../../../lib/twrk60d100m.uv4/debug/bsp;../../../../../../../lib/twrk60d100m.uv4/debug/shell;../../../../../../../lib/twrk60d100m.uv4/debug/psp;../../../../../../../lib/twrk60d100m.uv4/debug/usb;../../../../../../../usb/host/examples/audio/speaker;../../../../../../../lib/twrk60d100m.uv4/debug/bsp/Generated_Code;../../../../../../../lib/twrk60d100m.uv4/debug/bsp/Sources;../../../../../../../lib/twrk60d100m.uv4/debug;../../../../../../../lib/twrk60d100m.uv4/debug/mfs
  asm define: _DEBUG=1
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../lib/twrk60d100m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../lib/twrk60d100m.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../../../../lib/twrk60d100m.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
  group Source
    ../../../../../../../usb/host/examples/audio/speaker/: sd_card.c audio_speaker.c usb_classes.h sh_audio.c audio_speaker.h wav.c usb_classes.c sh_audio.h hidkeyboard.c sd_card.h wav.h hidkeyboard.h main.c
  group MQX Libraries
    ../../../../../../../lib/twrk60d100m.uv4/debug/shell/: shell.lib
    ../../../../../../../lib/twrk60d100m.uv4/debug/mfs/: mfs.lib
    ../../../../../../../lib/twrk60d100m.uv4/release/psp/: psp.lib
    ../../../../../../../lib/twrk60d100m.uv4/release/mfs/: mfs.lib
    ../../../../../../../lib/twrk60d100m.uv4/release/usb/: usbh.lib
    ../../../../../../../lib/twrk60d100m.uv4/debug/usb/: usbh.lib
    ../../../../../../../lib/twrk60d100m.uv4/debug/psp/: psp.lib
    ../../../../../../../lib/twrk60d100m.uv4/debug/bsp/: bsp.lib
    ../../../../../../../lib/twrk60d100m.uv4/release/bsp/: bsp.lib
    ../../../../../../../lib/twrk60d100m.uv4/release/shell/: shell.lib
target speaker_host Int Flash Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: speaker_host +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: ../../../../../../../lib/twrk60d100m.uv4/release/bsp/Sources;../../../../../../../lib/twrk60d100m.uv4/release/shell;../../../../../../../lib/twrk60d100m.uv4/release/psp;../../../../../../../lib/twrk60d100m.uv4/release/bsp/Generated_Code;../../../../../../../lib/twrk60d100m.uv4/release/usb;../../../../../../../usb/host/examples/audio/speaker;../../../../../../../lib/twrk60d100m.uv4/release/bsp;../../../../../../../lib/twrk60d100m.uv4/release;../../../../../../../lib/twrk60d100m.uv4/release/mfs
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../../lib/twrk60d100m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../lib/twrk60d100m.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../../../../lib/twrk60d100m.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
