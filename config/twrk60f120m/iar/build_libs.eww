<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_twrk60f120m\bsp_twrk60f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mfs\build\iar\mfs_twrk60f120m\mfs_twrk60f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\psp_twrk60f120m\psp_twrk60f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\rtcs\build\iar\rtcs_twrk60f120m\rtcs_twrk60f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\shell\build\iar\shell_twrk60f120m\shell_twrk60f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usb\device\build\iar\usbd_twrk60f120m\usbd_twrk60f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usb\host\build\iar\usbh_twrk60f120m\usbh_twrk60f120m.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>psp_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>bsp_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbh_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbh_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>psp_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbh_twrk60f120m</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>psp_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>bsp_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbh_twrk60f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


