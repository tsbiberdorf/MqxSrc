<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_twrk60n512\bsp_twrk60n512.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\psp_twrk60n512\psp_twrk60n512.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\rtcs\build\iar\rtcs_twrk60n512\rtcs_twrk60n512.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mfs\build\iar\mfs_twrk60n512\mfs_twrk60n512.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\shell\build\iar\shell_twrk60n512\shell_twrk60n512.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usb\device\build\iar\usbd_twrk60n512\usbd_twrk60n512.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\usb\host\build\iar\usbh_twrk60n512\usbh_twrk60n512.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>bsp_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbh_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbh_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>bsp_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbd_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usbh_twrk60n512</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>bsp_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>rtcs_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbd_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usbh_twrk60n512</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


