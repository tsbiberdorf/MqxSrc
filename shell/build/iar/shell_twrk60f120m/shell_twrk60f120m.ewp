# IAR project shell_twrk60f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../usb/host/source/rtos/mqx; ../../../../usb/host/source/include; ../../../../usb/host/source/host/khci; ../../../../usb/host/source/host/ehci; ../../../../usb/host/source/classes/printer; ../../../../usb/host/source/classes/phdc; ../../../../usb/host/source/classes/msd/mfs; ../../../../usb/host/source/classes/msd; ../../../../usb/host/source/classes/hub; ../../../../usb/host/source/classes/hid; ../../../../usb/host/source/classes/cdc; ../../../../usb/host/source/classes/audio; ../../../../usb/device/source/include/rtos; ../../../../usb/device/source/include/khci; ../../../../usb/device/source/include/ehci; ../../../../usb/device/source/include; ../../../../usb/device/source/classes/include; ../../../../usb/common/include; ../../../../shell/source/include; ../../../../rtcs/source/include; ../../../../rtcs/source/httpd; ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_dun; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/crc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/include; ../../../../mqx/source/bsp/twrk60f120m; ../../../../mfs/source/include; ../../../../config/twrk60f120m; ../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../shell/build/bat/shell_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/shell" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../shell/build/bat/shell_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/shell" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group Shell Source/mfs
    ../../../../shell/source/mfs/: sh_dirent.c sh_pwd.c sh_di.c sh_df.c sh_read.c sh_dir.c sh_cache.c sh_copy.c sh_disect.c sh_format.c sh_create.c sh_readtest.c sh_write.c sh_del.c sh_rename.c sh_cd.c sh_rmdir.c sh_writetest.c sh_flush.c sh_mkdir.c sh_compare.c sh_type.c
    ../../../../shell/source/include/: sh_mfs.h
  group Shell Source/mqx
    ../../../../shell/source/mqx/: sh_tad.c sh_abort.c sh_pause.c sh_kill.c
    ../../../../shell/source/include/: shell.h sh_prv.h
  group Shell Source/rtcs
    ../../../../shell/source/rtcs/: sh_tnet.c sh_load.c sh_ftpc.c sh_gate.c sh_rtcs.c sh_ipconfig.c sh_nstat.c sh_nat.c sh_ftpd.c sh_iwconfig.c sh_ppp.c sh_exec.c sh_clock.c sh_ping.c sh_getroute.c sh_eds.c sh_echod.c sh_enet.c sh_tftpd.c sh_arpdisp.c sh_ghbn.c sh_snmpd.c sh_tnetd.c sh_sendto.c sh_tftp.c
  group Shell Source/shell
    ../../../../shell/source/shell/: shell.c sh_cmdlist.c sh_help.c sh_sh.c sh_exit.c sh_util.c
    ../../../../shell/source/include/: sh_rtcs.h sh_enet.h
