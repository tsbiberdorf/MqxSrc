# Keil uVision project shell_twrk60n512.uvproj, settings and files
target shell_twrk60n512 Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: shell (library)
  AfterMake: ../../../../shell/build/bat/shell_twrk60n512.bat ../../../.. ../../../../lib/twrk60n512.uv4/debug/shell uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\shell_twrk60n512_debug\shell.lib ..\..\..\..\lib\twrk60n512.uv4\debug\shell\shell.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/lpm;../../../../mqx/source/io/adc;../../../../mqx/source/io/serial;../../../../mqx/source/io/i2c/polled;../../../../usb/device/source/include;../../../../usb/common/include;../../../../usb/device/source/include/khci;../../../../usb/host/source/classes/hid;../../../../mqx/source/tad;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/i2c/int;../../../../usb/host/source/classes/phdc;../../../../usb/host/source/include;../../../../mqx/source/io/io_mem;../../../../usb/device/source/include/rtos;../../../../usb/host/source/rtos/mqx;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/i2s/int;../../../../mqx/source/io/i2s;../../../../mqx/source/io/timer;../../../../shell/source/include;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../usb/host/source/classes/msd/mfs;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/tchres;../../../../mqx/source/io/rtc;../../../../mqx/source/io/io_null;../../../../mqx/source/io/hwtimer;../../../../usb/host/source/host/khci;../../../../mqx/source/bsp/twrk60n512;../../../../mqx/source/io/usb;../../../../mqx/source/io/spi;../../../../mfs/source/include;../../../../mqx/source/io/tfs;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/adc/kadc;../../../../usb/host/source/classes/hub;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pipe;../../../../mqx/source/psp/cortex_m;../../../../usb/host/source/classes/audio;../../../../mqx/source/io/gpio/kgpio;../../../../usb/host/source/classes/msd;../../../../mqx/source/io/i2c;../../../../mqx/source/io/pccard;../../../../mqx/source/io/hmi;../../../../mqx/source/include;../../../../mqx/source/io/hmi/TSS/shared;../../../../mqx/source/io/debug;../../../../rtcs/source/include;../../../../usb/device/source/classes/include;../../../../usb/host/source/classes/printer;../../../../mqx/source/io/gpio;../../../../mqx/source/io/can/flexcan;../../../../rtcs/source/httpd;../../../../mqx/source/io/cm;../../../../mqx/source/io/pcb/mqxa;../../../../config/twrk60n512;../../../../mqx/source/io/enet;../../../../mqx/source/psp/cortex_m/cpu;../../../../config/common;../../../../mqx/source/psp/cortex_m/core/M4;../../../../usb/host/source/classes/cdc;../../../../mqx/source/io/io_dun;../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../mqx/source/io/flashx
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
  group Shell Source:mfs
    ../../../../shell/source/mfs/: sh_write.c sh_cd.c sh_flush.c sh_create.c sh_pwd.c sh_disect.c sh_rmdir.c sh_readtest.c sh_mkdir.c sh_format.c sh_rename.c sh_dirent.c sh_del.c sh_copy.c sh_cache.c sh_df.c sh_type.c sh_read.c sh_dir.c sh_writetest.c sh_compare.c sh_di.c
    ../../../../shell/source/include/: sh_mfs.h
  group Shell Source:rtcs
    ../../../../shell/source/rtcs/: sh_clock.c sh_tftp.c sh_nat.c sh_getroute.c sh_tftpd.c sh_enet.c sh_sendto.c sh_echod.c sh_ftpd.c sh_ppp.c sh_exec.c sh_ping.c sh_load.c sh_ftpc.c sh_arpdisp.c sh_tnet.c sh_gate.c sh_iwconfig.c sh_tnetd.c sh_nstat.c sh_ipconfig.c sh_snmpd.c sh_eds.c sh_ghbn.c sh_rtcs.c
  group Shell Source:shell
    ../../../../shell/source/shell/: sh_exit.c sh_sh.c sh_help.c sh_cmdlist.c sh_util.c shell.c
    ../../../../shell/source/include/: sh_rtcs.h sh_enet.h
  group Shell Source:mqx
    ../../../../shell/source/mqx/: sh_kill.c sh_pause.c sh_tad.c sh_abort.c
    ../../../../shell/source/include/: shell.h sh_prv.h
target shell_twrk60n512 Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: shell (library)
  AfterMake: ../../../../shell/build/bat/shell_twrk60n512.bat ../../../.. ../../../../lib/twrk60n512.uv4/release/shell uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\shell_twrk60n512_release\shell.lib ..\..\..\..\lib\twrk60n512.uv4\release\shell\shell.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
