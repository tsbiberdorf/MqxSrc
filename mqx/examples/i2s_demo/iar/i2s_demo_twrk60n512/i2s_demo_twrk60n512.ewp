# IAR project i2s_demo_twrk60n512.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../mqx/examples/i2s_demo; ../../../../../lib/twrk60n512.iar/debug/shell; ../../../../../lib/twrk60n512.iar/debug/psp; ../../../../../lib/twrk60n512.iar/debug/mfs; ../../../../../lib/twrk60n512.iar/debug/bsp/Sources; ../../../../../lib/twrk60n512.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk60n512.iar/debug/bsp; ../../../../../lib/twrk60n512.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: twrk60n512.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk60n512.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../../../../../mqx/examples/i2s_demo; ../../../../../lib/twrk60n512.iar/release/shell; ../../../../../lib/twrk60n512.iar/release/psp; ../../../../../lib/twrk60n512.iar/release/mfs; ../../../../../lib/twrk60n512.iar/release/bsp/Sources; ../../../../../lib/twrk60n512.iar/release/bsp/Generated_Code; ../../../../../lib/twrk60n512.iar/release/bsp; ../../../../../lib/twrk60n512.iar/release
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrk60n512.iar/release/bsp/intflash.icf
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../../../../../lib/twrk60n512.iar/debug/bsp/ram.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../lib/twrk60n512.iar/release/bsp/ram.icf
  group Source
    ../../../../../mqx/examples/i2s_demo/: log_messages.h sh_audio.h sh_audio.c main.c log_messages.c main.h sgtl5000.h wav.c sgtl5000.c wav.h
  group MQX Libraries
    ../../../../../lib/twrk60n512.iar/debug/shell/: shell.a
    ../../../../../lib/twrk60n512.iar/release/mfs/: mfs.a
    ../../../../../lib/twrk60n512.iar/release/bsp/: bsp.a
    ../../../../../lib/twrk60n512.iar/debug/bsp/: bsp.a
    ../../../../../lib/twrk60n512.iar/release/psp/: psp.a
    ../../../../../lib/twrk60n512.iar/debug/psp/: psp.a
    ../../../../../lib/twrk60n512.iar/debug/mfs/: mfs.a
    ../../../../../lib/twrk60n512.iar/release/shell/: shell.a
