# IAR project bsp_twrk60f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_dun; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/crc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/include; ../../../../mqx/source/bsp/twrk60f120m; ../../../../config/twrk60f120m; ../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../mqx/build/bat/bsp_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/bsp" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../mqx/build/bat/bsp_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/bsp" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group twrk60f120m BSP Files
    ../../../../mqx/source/bsp/twrk60f120m/: init_lpm.h bsp_rev.h vectors.c init_esdhc.c bsp_cm.h twrk60f120m.h init_hw.c init_sdcard.c mqx_init.c bsp_prv.h init_usb_dcd.c PE_Types.h PE_LDD.h mqx_main.c init_bsp.c init_adc.c init_tchres.c init_sai.c init_lpm.c init_spi.c init_enet.c init_i2c.c bsp_cm.c init_iodebug.c init_flashx.c init_cfcard.c init_sci.c bsp.h init_usb.c init_gpio.c init_nandflash.c
    ../../../../config/common/: verif_enabled_config.h smallest_config.h maximum_config.h small_ram_config.h
    ../../../../mqx/source/io/enet/: enet.h ethernet.h enet_wifi.h
    ../../../../mqx/source/include/: mqx.h
  group Generic IO Drivers/iopipe
    ../../../../mqx/source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/pcb
    ../../../../mqx/source/io/pcb/: io_pcb.h io_pcb.c io_pcb2.c iopcbprv.h iop_inst.c
    ../../../../mqx/source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Generic IO Drivers/tfs
    ../../../../mqx/source/io/tfs/: tfs_prv.h tfs.h tfs.c
  group Generic IO Drivers/io_dun
    ../../../../mqx/source/io/io_dun/: io_dun.c io_dun.h
  group Generic IO Drivers/lpm
    ../../../../mqx/source/io/lpm/: lpm.c lpm_smc.c lpm_prv.h lpm_kinetis.h lpm.h
  group Generic IO Drivers/cm
    ../../../../mqx/source/io/cm/: cm.c cm.h cm_kinetis.h
  group Generic IO Drivers/io_null
    ../../../../mqx/source/io/io_null/: ionulprv.h io_null.c io_null.h
  group Generic IO Drivers/io_mem
    ../../../../mqx/source/io/io_mem/: io_mem.h iomemprv.h io_mem.c
  group Generic IO Drivers/debug
    ../../../../mqx/source/io/debug/: iodebug.c iodebug_prv.h iodebug.h iodebug_asm.S
  group Peripheral IO Drivers/adc
    ../../../../mqx/source/io/adc/kadc/: adc_mk60.h adc_mk60.c
    ../../../../mqx/source/io/adc/: adc_prv.h adc.c adc_conf.h adc.h
  group Peripheral IO Drivers/adc/kadc
    ../../../../mqx/source/io/adc/kadc/: adc_kadc.h adc_kadc.c adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/spi
    ../../../../mqx/source/io/spi/: spi_dspi.c spi.h spi_dspi_prv.h spi_dspi.h spi_prv.h spi.c spi_mk60.c
  group Peripheral IO Drivers/lwgpio
    ../../../../mqx/source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../../../mqx/source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/enet
    ../../../../mqx/source/io/enet/: enutil.c enopen.c enmediactl.c eninit.c enjoin.c enstat.c ensend.c enaddr.c enclose.c enetprv.h enstop.c enleave.c enet_rev.h enerr.c enrecv.c
    ../../../../mqx/source/io/enet/macnet/: macnet_mk60.h macnet_mk60.c
  group Peripheral IO Drivers/enet/macnet
    ../../../../mqx/source/io/enet/macnet/: macnet_send.c macnet_util.c macnet_stop.c macnet_mii.c macnet_receive.c macnet_prv.h macnet_join.c macnet_rejoin.c macnet_init.c macnet_1588.h macnet_1588.c macnet_rev.h
  group Peripheral IO Drivers/enet/phy
    ../../../../mqx/source/io/enet/phy/: phy_ksz8041.h phy_ksz8041.c
  group Peripheral IO Drivers/sdcard
    ../../../../mqx/source/io/sdcard/: sdcard.c sdcard_prv.h sdcard.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../../../mqx/source/io/sdcard/sdcard_spi/: sdcard_spi.h sdcard_spi.c
  group Peripheral IO Drivers/sdcard/sdcard_esdhc
    ../../../../mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.h sdcard_esdhc.c
  group Peripheral IO Drivers/esdhc
    ../../../../mqx/source/io/esdhc/: esdhc.c esdhc_mk60.c esdhc_prv.h esdhc.h
  group Peripheral IO Drivers/i2c
    ../../../../mqx/source/io/i2c/: i2c_ki2c.h i2c_mk60.c i2c_ki2c_prv.h i2c.h
    ../../../../mqx/source/io/i2c/polled/: i2c_pol_ki2c.c
    ../../../../mqx/source/io/i2c/int/: i2c_int_ki2c.c
  group Peripheral IO Drivers/i2c/polled
    ../../../../mqx/source/io/i2c/polled/: i2c_pol_prv.h i2c_pol.c
  group Peripheral IO Drivers/i2c/int
    ../../../../mqx/source/io/i2c/int/: i2c_int.c i2c_int_prv.h
  group Peripheral IO Drivers/usb_dcc
    ../../../../mqx/source/io/usb_dcd/: usb_dcd_kn.h usb_dcd_mk60.c usb_dcd_kn_prv.h usb_dcd.h
  group Peripheral IO Drivers/usb_dcc/int
    ../../../../mqx/source/io/usb_dcd/int/: usb_dcd_int_kn.c usb_dcd_int_prv.h usb_dcd_int.c
  group Peripheral IO Drivers/usb_dcc/polled
    ../../../../mqx/source/io/usb_dcd/polled/: usb_dcd_pol.c usb_dcd_pol_prv.h usb_dcd_pol_kn.c
  group Peripheral IO Drivers/gpio
    ../../../../mqx/source/io/gpio/: io_gpio.c io_gpio_prv.h io_gpio.h
  group Peripheral IO Drivers/gpio/knxx
    ../../../../mqx/source/io/gpio/kgpio/: io_gpio_kgpio.h io_gpio_kgpio_prv.h io_gpio_kgpio.c
  group Peripheral IO Drivers/serial
    ../../../../mqx/source/io/serial/: io_sinit.c serplprv.h serl_kuart.h serl_mk60.c serial.h serinprv.h
  group Peripheral IO Drivers/serial/polled
    ../../../../mqx/source/io/serial/polled/: serl_pol_kuart.c serl_pol.c
  group Peripheral IO Drivers/serial/int
    ../../../../mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
  group Peripheral IO Drivers/sai
    ../../../../mqx/source/io/sai/: sai_ksai.h sai_mk60.c sai_ksai_prv.h sai.h
  group Peripheral IO Drivers/sai/int
    ../../../../mqx/source/io/sai/int/: sai_int_prv.h sai_int_ksai.c sai_int.c
  group Peripheral IO Drivers/pcflash
    ../../../../mqx/source/io/pcflash/: ata.h apcflshpr.h apcflash.c pcflash.h
  group Peripheral IO Drivers/usb
    ../../../../mqx/source/io/usb/: usb_mk60f.c usb_mk60f_device.c if_host_khci.h usb_install.c if_dev_ehci.h if_dev_khci.h if_host_ehci.h usb_bsp.h
  group Peripheral IO Drivers/flashx
    ../../../../mqx/source/io/flashx/freescale/: flash_mk60.c flash_mk60.h
    ../../../../mqx/source/io/flashx/: flashxprv.h flashx.c flashx.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../../mqx/source/io/flashx/freescale/: flash_ftfe_prv.h flash_ftfe.c flash_ftfe.h
  group Peripheral IO Drivers/rtc
    ../../../../mqx/source/io/rtc/: krtc_ext.c krtc.c krtc.h rtc.h krtc_ext.h
  group Peripheral IO Drivers/flexcan
    ../../../../mqx/source/io/can/flexcan/: kflexcan_int.c flexcan_mk60.c kflexcan.c kflexcan.h
  group Peripheral IO Drivers/nandflash
    ../../../../mqx/source/io/nandflash/nfc/: nfc_k60f120m.c nfc.h nfc.c
    ../../../../mqx/source/io/nandflash/: nandflashprv.h nandflash.h nandflash.c
    ../../../../mqx/source/io/nandflash/nand_devices/: MT29F2G16.c
  group Peripheral IO Drivers/hwtimer
    ../../../../mqx/source/io/hwtimer/: hwtimer_pit.c hwtimer.h hwtimer_kinetis.c hwtimer_pit.h hwtimer.c
  group Peripheral IO Drivers/timer
    ../../../../mqx/source/io/timer/: timer_lpt_kinetis.c timer_qpit.h timer_kinetis.c timer_lpt.h qpit.h timer_qpit.c timer_lpt.c
  group Peripheral IO Drivers/tchres
    ../../../../mqx/source/io/tchres/: tchres.h tchres_prv.h tchres.c
  group Peripheral IO Drivers/pccard
    ../../../../mqx/source/io/pccard/: pccardflexbus.h apccard.h pccardflexbuspr.h pccardflexbus.c
  group Peripheral IO Drivers/crc
    ../../../../mqx/source/io/crc/: crc_kn.h crc_kn.c
  group twrk60f120m User Config
    ../../../../config/twrk60f120m/: user_config.h
