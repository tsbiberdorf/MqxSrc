# IAR project psp_twrk60f120m.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550
  ICCARM.CCIncludePath2: ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/io/usb_dcd/polled; ../../../../mqx/source/io/usb_dcd/int; ../../../../mqx/source/io/usb_dcd; ../../../../mqx/source/io/usb; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/tchres; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard/sdcard_esdhc; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/nandflash/nfc; ../../../../mqx/source/io/nandflash; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_dun; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/esdhc; ../../../../mqx/source/io/enet/phy; ../../../../mqx/source/io/enet/macnet; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/crc; ../../../../mqx/source/io/cm; ../../../../mqx/source/io/can/flexcan; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../mqx/source/include; ../../../../mqx/source/bsp/twrk60f120m; ../../../../config/twrk60f120m; ../../../../config/common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: as above
  postbuild: "../../../../mqx/build/bat/psp_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/debug/psp" iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: MQX_DISABLE_CONFIG_CHECK=1
  ICCARM.CCOptLevel: 3
  postbuild: "../../../../mqx/build/bat/psp_twrk60f120m.bat" "../../../.." "../../../../lib/twrk60f120m.iar/release/psp" iar
  ILINK.IlinkOutputFile: libgeneric.out
  group PSP Generic/kernel
    ../../../../mqx/source/kernel/: lwtimer.c queue.c log.c sched.c lwevent.c idletask.c task.c mqx.c ipc.c taskq.c msgpool.c timer.c msgq.c partition.c mutex.c lwsem.c time_tables.c mem.c msg.c int.c klog.c sem.c lwmsgq.c watchdog.c event.c name.c lwlog.c lwmem.c time.c
  group PSP Generic/include
    ../../../../mqx/source/include/: mqx_prv.h ioctl.h timer.h log.h posix.h lwevent.h name.h mutex_prv.h event.h mqx_ioc.h ipc.h edserial.h mmu.h event_prv.h fpio_prv.h mqx_cpudef.h mem_prv.h lwmsgq_prv.h watchdog.h edserprv.h gen_rev.h mqx_inc.h partition.h lwmsgq.h mutex.h mqx_str.h lwlog_prv.h eds.h klog.h fio.h eds_prv.h ipcrtprv.h lwtimer.h timer_prv.h charq.h lwevent_prv.h lwlog.h ipc_pcbv.h queue.h name_prv.h partition_prv.h mqx.h lwmem.h message.h mqx_cnfg.h lwtimer_prv.h io_prv.h fio_prv.h ipc_pcb.h io_rev.h lwsem.h watchdog_prv.h io.h sem_prv.h sem.h mqx_macros.h lwmem_prv.h msg_prv.h log_prv.h ipc_prv.h pcb.h
  group PSP Generic/fio
    ../../../../mqx/source/fio/: io_fgetl.c io_misc.c io_fputs.c io_vpr.c io_fgets.c io_fp.c io_dopr.c io_clre.c io_fflsh.c io_scanl.c io_sscan.c io_scanf.c io_fscan.c io_fprt.c io_ioctl.c io_read.c io_pntf.c io_fung.c io_ferr.c io_fputc.c io_fstat.c io_fgetc.c io_fclos.c io_write.c io_spr.c io_fseek.c io_ftell.c io_util.c io_fopen.c io_feof.c
  group PSP Generic/io
    ../../../../mqx/source/io/: io_inst.c io_shand.c io_init.c io_uinst.c io_instx.c io_ghand.c
  group PSP Generic/string
    ../../../../mqx/source/string/: strnlen.c str_utos.c
  group PSP Generic/tad
    ../../../../mqx/source/tad/: tad.h tad.c
  group PSP Cortex
    ../../../../mqx/source/psp/cortex_m/: psp_tius.c psp.h nvic.h cache.c psp_tida.c psp_mstiq.c psp_supp.h psp_tisu.c psp_comp.h psp_abi.h psp_cpu.h psp_tkti.c stack_bu.c kinetis_mpu.c mem_copy.c psp_dati.c psp_tiol.c kinetis.h int_pvta.c psp_timn.c psp_tixd.c psp_tims.c nvic.c mem_zero.c psp_mat2.c int_xcpt.c psp_msti.c psp_gelms.c int_inst.c psp_mat1.c stack_de.c psptypes.h stack_st.c psp_tins.c sc_irdyq.c psp_psti.c kinetis_mpu.h int_kisr.c psp_nsti.c psp_cpudef.h psp_tiad.c psp_rev.h psp_math.h int_unx.c psp_iinit.c psp_miti.c psp_tips.c psp_tihr.c cortex.c psp_tinm.c psp_tipr.c psp_hoti.c psp_mat3.c int_gkis.c int_vtab.c psp_seti.c psp_tise.c psp_usti.c ipsum.c psp_prv.h cortex.h psp_time.h psp_supp.c
    ../../../../mqx/source/psp/cortex_m/cpu/: MK60F15.h kinetis_fcan.h
    ../../../../mqx/source/psp/cortex_m/core/M4/: boot.S dispatch.S
  group PSP Cortex/compiler
    ../../../../mqx/source/psp/cortex_m/compiler/iar/: comp.c comp.h asm_mac.h kernel_symbols.S
  group twrk60f120m User Config
    ../../../../config/common/: small_ram_config.h
    ../../../../config/twrk60f120m/: user_config.h
