# Keil uVision project psp_twrk60f120m.uvproj, settings and files
target psp_twrk60f120m Debug (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2 ELITTLE
  output: psp (library)
  AfterMake: ../../../../mqx/build/bat/psp_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/debug/psp uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\psp_twrk60f120m_debug\psp.lib ..\..\..\..\lib\twrk60f120m.uv4\debug\psp\psp.lib
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK=1, _DEBUG=1
  c misc: --c99
  c include: ../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/adc;../../../../mqx/source/io/lpm;../../../../mqx/source/io/serial;../../../../mqx/source/io/pcb;../../../../mqx/source/io/sai;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/pipe;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/tad;../../../../mqx/source/io/usb_dcd/int;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/i2c/int;../../../../mqx/source/io/usb_dcd;../../../../mqx/source/io/i2c;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/pccard;../../../../mqx/source/include;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/debug;../../../../mqx/source/bsp/twrk60f120m;../../../../mqx/source/io/timer;../../../../mqx/source/io/crc;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/usb_dcd/polled;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../config/twrk60f120m;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/gpio;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/nandflash/nfc;../../../../mqx/source/io/cm;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/rtc;../../../../mqx/source/io/tchres;../../../../mqx/source/io/enet;../../../../mqx/source/io/hwtimer;../../../../config/common;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/io/io_null;../../../../mqx/source/io/nandflash;../../../../mqx/source/io/usb;../../../../mqx/source/io/io_dun;../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/flashx
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
  group PSP Cortex
    ../../../../mqx/source/psp/cortex_m/: psp_tinm.c psp_iinit.c psp_tisu.c stack_st.c int_kisr.c psp_hoti.c psp_supp.h sc_irdyq.c psp_mat1.c mem_zero.c psp_tiad.c psp_cpu.h nvic.c psp_mat2.c nvic.h int_vtab.c psp_tise.c psp_usti.c psp_math.h psp_tius.c psp_tkti.c kinetis_mpu.h psp_supp.c int_unx.c psp_mat3.c psp_seti.c int_gkis.c kinetis_mpu.c psptypes.h mem_copy.c stack_bu.c psp_prv.h psp_tixd.c psp_cpudef.h psp_time.h psp_tihr.c psp_tips.c psp_tins.c psp_comp.h psp_rev.h psp.h psp_dati.c ipsum.c cortex.h kinetis.h psp_timn.c int_inst.c psp_msti.c psp_gelms.c psp_abi.h cortex.c psp_tipr.c psp_tiol.c psp_tida.c cache.c stack_de.c psp_nsti.c int_pvta.c psp_mstiq.c int_xcpt.c psp_tims.c psp_miti.c psp_psti.c
    ../../../../mqx/source/psp/cortex_m/cpu/: kinetis_fcan.h MK60F15.h
    ../../../../mqx/source/psp/cortex_m/core/M4/: boot.S dispatch.S
  group PSP Generic:fio
    ../../../../mqx/source/fio/: io_fopen.c io_fp.c io_fclos.c io_ftell.c io_fgets.c io_scanf.c io_fflsh.c io_fputc.c io_fprt.c io_sscan.c io_fputs.c io_fgetl.c io_fung.c io_ferr.c io_spr.c io_fgetc.c io_scanl.c io_feof.c io_fscan.c io_dopr.c io_ioctl.c io_write.c io_clre.c io_vpr.c io_read.c io_pntf.c io_util.c io_fseek.c io_misc.c io_fstat.c
  group PSP Generic:include
    ../../../../mqx/source/include/: event_prv.h mqx_cpudef.h lwsem.h lwmsgq.h watchdog_prv.h ipc_pcbv.h lwlog_prv.h gen_rev.h mqx_prv.h event.h lwtimer_prv.h charq.h watchdog.h pcb.h timer.h io_rev.h eds.h edserial.h message.h mutex_prv.h name_prv.h mqx_macros.h mqx_inc.h timer_prv.h fio.h partition.h io_prv.h mqx_ioc.h mqx_str.h mmu.h ipc.h log.h posix.h name.h lwmem_prv.h lwmsgq_prv.h sem_prv.h ipc_pcb.h mutex.h log_prv.h sem.h lwevent_prv.h fio_prv.h partition_prv.h lwevent.h eds_prv.h mqx_cnfg.h fpio_prv.h msg_prv.h lwtimer.h ipcrtprv.h queue.h edserprv.h ipc_prv.h lwmem.h ioctl.h lwlog.h klog.h mqx.h io.h mem_prv.h
  group PSP Generic:io
    ../../../../mqx/source/io/: io_shand.c io_inst.c io_uinst.c io_ghand.c io_instx.c io_init.c
  group twrk60f120m User Config
    ../../../../config/twrk60f120m/: user_config.h
    ../../../../config/common/: small_ram_config.h
  group PSP Generic:kernel
    ../../../../mqx/source/kernel/: mutex.c taskq.c mqx.c lwevent.c idletask.c event.c klog.c lwlog.c log.c mem.c int.c sched.c time_tables.c lwmem.c sem.c timer.c ipc.c msg.c lwmsgq.c name.c lwtimer.c watchdog.c queue.c msgq.c time.c partition.c msgpool.c lwsem.c task.c
  group PSP Generic:tad
    ../../../../mqx/source/tad/: tad.h tad.c
  group PSP Generic:string
    ../../../../mqx/source/string/: strnlen.c str_utos.c
  group PSP Cortex:compiler
    ../../../../mqx/source/psp/cortex_m/compiler/rv/: linker_symbols.S comp.c comp.h asm_mac.h
target psp_twrk60f120m Release (ARM-ADS)
  device: MK60FN1M0xxx12 Freescale Semiconductor
  cpu: as above
  output: psp (library)
  AfterMake: ../../../../mqx/build/bat/psp_twrk60f120m.bat ../../../.. ../../../../lib/twrk60f120m.uv4/release/psp uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\psp_twrk60f120m_release\psp.lib ..\..\..\..\lib\twrk60f120m.uv4\release\psp\psp.lib
  c flags: Optim=4 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60f120m.uv4\mqx\intflash.scf
