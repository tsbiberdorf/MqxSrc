# Keil uVision project bsp_twrk60n512.uvproj, settings and files
target bsp_twrk60n512 Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: bsp (library)
  AfterMake: ../../../../mqx/build/bat/bsp_twrk60n512.bat ../../../.. ../../../../lib/twrk60n512.uv4/debug/bsp uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\bsp_twrk60n512_debug\bsp.lib ..\..\..\..\lib\twrk60n512.uv4\debug\bsp\bsp.lib
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --c99
  c include: ../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/adc;../../../../mqx/source/io/lpm;../../../../mqx/source/io/serial;../../../../mqx/source/io/pcb;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/pipe;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/tad;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/i2c/int;../../../../mqx/source/io/i2c;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/pccard;../../../../mqx/source/include;../../../../mqx/source/io/hmi;../../../../mqx/source/io/hmi/TSS/shared;../../../../mqx/source/io/i2s/int;../../../../mqx/source/io/sdcard/sdcard_esdhc;../../../../mqx/source/io/debug;../../../../mqx/source/io/i2s;../../../../mqx/source/io/timer;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/esdhc;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/gpio;../../../../mqx/source/io/can/flexcan;../../../../mqx/source/io/cm;../../../../mqx/source/io/pcb/mqxa;../../../../config/twrk60n512;../../../../mqx/source/io/enet/macnet;../../../../mqx/source/io/tchres;../../../../mqx/source/io/rtc;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/io/enet;../../../../config/common;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/io_null;../../../../mqx/source/bsp/twrk60n512;../../../../mqx/source/io/usb;../../../../mqx/source/psp/cortex_m/compiler/rv;../../../../mqx/source/io/io_dun;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/enet/phy;../../../../mqx/source/io/flashx
  asm define: _DEBUG=1
  asm misc: --cpreproc --diag_suppress=1609
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
  group Peripheral IO Drivers:enet:macnet
    ../../../../mqx/source/io/enet/macnet/: macnet_join.c macnet_stop.c macnet_init.c macnet_rejoin.c macnet_send.c macnet_mii.c macnet_rev.h macnet_1588.h macnet_receive.c macnet_prv.h macnet_1588.c macnet_util.c
  group Peripheral IO Drivers:i2c
    ../../../../mqx/source/io/i2c/int/: i2c_int_ki2c.c
    ../../../../mqx/source/io/i2c/polled/: i2c_pol_ki2c.c
    ../../../../mqx/source/io/i2c/: i2c.h i2c_mk60.c i2c_ki2c_prv.h i2c_ki2c.h
  group Generic IO Drivers:hmi:tss
    ../../../../mqx/source/io/hmi/TSS/shared/: TSS_SensorTSIL.c TSS_SensorGPIO.c TSS_API.h TSS_Freemaster.c TSS_GPIO.h TSS_SensorTSI.h TSS_SystemSetupVal.h TSS_SensorTSIL.h TSS_StatusCodes.h TSS_Sensor.c TSS_Timer.h TSS_DataTypes.h TSS_Sensor.h TSS_SystemSetupData.c TSS_SensorGPIO.h TSS_SensorTSI.c
  group Peripheral IO Drivers:esdhc
    ../../../../mqx/source/io/esdhc/: esdhc_mk60.c esdhc.c esdhc_prv.h esdhc.h
  group Peripheral IO Drivers:sdcard:sdcard_spi
    ../../../../mqx/source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group twrk60n512 BSP Files
    ../../../../mqx/source/bsp/twrk60n512/: init_lpm.h init_cfcard.c bsp_cm.h init_i2c.c bsp.h init_sdcard.c init_lpm.c init_adc.c init_hmi.c init_esdhc.c mqx_init.c init_iodebug.c vectors.c init_tchres.c init_sci.c init_i2s.c mqx_main.c init_hw.c init_flashx.c init_gpio.c twrk60n512.h PE_LDD.h init_usb.c init_spi.c TSS_SystemSetup.h init_bsp.c bsp_prv.h bsp_cm.c bsp_rev.h init_enet.c
    ../../../../mqx/source/io/enet/: enet.h ethernet.h enet_wifi.h
    ../../../../config/common/: smallest_config.h small_ram_config.h verif_enabled_config.h maximum_config.h
    ../../../../mqx/source/include/: mqx.h
  group Peripheral IO Drivers:flexcan
    ../../../../mqx/source/io/can/flexcan/: flexcan_mk60.c kflexcan_int.c kflexcan.c kflexcan.h
  group Peripheral IO Drivers:pcflash
    ../../../../mqx/source/io/pcflash/: ata.h pcflash.h apcflash.c apcflshpr.h
  group Peripheral IO Drivers:usb
    ../../../../mqx/source/io/usb/: if_host_ehci.h usb_mk60_device.c if_dev_ehci.h usb_install.c if_dev_khci.h if_host_khci.h usb_bsp.h usb_mk60.c
  group Generic IO Drivers:io_null
    ../../../../mqx/source/io/io_null/: io_null.c ionulprv.h io_null.h
  group Peripheral IO Drivers:hwtimer
    ../../../../mqx/source/io/hwtimer/: hwtimer.h hwtimer.c hwtimer_kinetis.c hwtimer_pit.h hwtimer_pit.c
  group Peripheral IO Drivers:enet
    ../../../../mqx/source/io/enet/macnet/: macnet_mk60.c macnet_mk60.h
    ../../../../mqx/source/io/enet/: enstat.c enaddr.c enerr.c enet_rev.h enetprv.h enrecv.c enclose.c enleave.c enutil.c enstop.c enjoin.c eninit.c enopen.c ensend.c enmediactl.c
  group Generic IO Drivers:lpm
    ../../../../mqx/source/io/lpm/: lpm.h lpm_kinetis.h lpm.c lpm_mc.c lpm_prv.h
  group Peripheral IO Drivers:spi
    ../../../../mqx/source/io/spi/: spi_dspi.h spi.h spi_prv.h spi_mk60.c spi.c spi_dspi.c spi_dspi_prv.h
  group Peripheral IO Drivers:rtc
    ../../../../mqx/source/io/rtc/: krtc.c rtc.h krtc.h
  group Peripheral IO Drivers:sdcard:sdcard_esdhc
    ../../../../mqx/source/io/sdcard/sdcard_esdhc/: sdcard_esdhc.h sdcard_esdhc.c
  group Generic IO Drivers:iopipe
    ../../../../mqx/source/io/pipe/: io_pipe.h io_pipe.c pipe_prv.h
  group Peripheral IO Drivers:serial
    ../../../../mqx/source/io/serial/: serinprv.h serl_kuart.h serial.h serplprv.h serl_mk60.c io_sinit.c
  group Generic IO Drivers:hmi
    ../../../../mqx/source/io/hmi/: btnled.h hmi_tss_provider.c derivative.h hmi_lwgpio_provider.h hmi_tss_provider.h hmi_uids.h hmi_provider.h hmi_client.h btnled.c hmi_client.c hmi_lwgpio_provider.c
  group Peripheral IO Drivers:i2s
    ../../../../mqx/source/io/i2s/: i2s_ki2s.h i2s.h i2s_ki2s_prv.h i2s_mk60.c i2s_audio.h
    ../../../../mqx/source/io/i2s/int/: i2s_int.c i2s_int_prv.h
  group Generic IO Drivers:tfs
    ../../../../mqx/source/io/tfs/: tfs.h tfs_prv.h tfs.c
  group Peripheral IO Drivers:timer
    ../../../../mqx/source/io/timer/: timer_kinetis.c timer_lpt.h timer_lpt.c timer_lpt_kinetis.c timer_qpit.h qpit.h timer_qpit.c
  group Generic IO Drivers:pcb
    ../../../../mqx/source/io/pcb/: io_pcb.c io_pcb.h iopcbprv.h iop_inst.c io_pcb2.c
    ../../../../mqx/source/io/pcb/mqxa/: pcb_mqxa.h pcbmqxav.h pcb_mqxa.c
  group Peripheral IO Drivers:pccard
    ../../../../mqx/source/io/pccard/: pccardflexbus.h pccardflexbuspr.h pccardflexbus.c apccard.h
  group Generic IO Drivers:cm
    ../../../../mqx/source/io/cm/: cm.c cm.h cm_kinetis.h
  group Peripheral IO Drivers:flashx
    ../../../../mqx/source/io/flashx/freescale/: flash_mk60.h flash_mk60.c
    ../../../../mqx/source/io/flashx/: flashx.c flashxprv.h flashx.h
  group Peripheral IO Drivers:adc
    ../../../../mqx/source/io/adc/: adc.h adc_prv.h adc.c adc_conf.h
    ../../../../mqx/source/io/adc/kadc/: adc_mk60.c adc_mk60.h
  group Peripheral IO Drivers:lwgpio
    ../../../../mqx/source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers:lwgpio:kgpio
    ../../../../mqx/source/io/lwgpio/: lwgpio_kgpio.h lwgpio_kgpio.c
  group Peripheral IO Drivers:sdcard
    ../../../../mqx/source/io/sdcard/: sdcard.h sdcard_prv.h sdcard.c
  group Peripheral IO Drivers:tchres
    ../../../../mqx/source/io/tchres/: tchres.c tchres.h tchres_prv.h
  group Peripheral IO Drivers:adc:kadc
    ../../../../mqx/source/io/adc/kadc/: adc_kadc_prv.h adt_kpdb.c adc_kadc.c adc_kadc.h
  group Generic IO Drivers:io_dun
    ../../../../mqx/source/io/io_dun/: io_dun.h io_dun.c
  group Peripheral IO Drivers:i2s:int
    ../../../../mqx/source/io/i2s/int/: i2s_int_ki2s.c
  group Peripheral IO Drivers:serial:int
    ../../../../mqx/source/io/serial/int/: serl_int.c serl_int_kuart.c
  group Generic IO Drivers:debug
    ../../../../mqx/source/io/debug/: iodebug_asm.S iodebug.c iodebug.h iodebug_prv.h
  group Peripheral IO Drivers:i2c:polled
    ../../../../mqx/source/io/i2c/polled/: i2c_pol_prv.h i2c_pol.c
  group Peripheral IO Drivers:serial:polled
    ../../../../mqx/source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group Peripheral IO Drivers:flashx:freescale
    ../../../../mqx/source/io/flashx/freescale/: flash_ftfl.c flash_ftfl_prv.h flash_ftfl.h
  group Peripheral IO Drivers:gpio
    ../../../../mqx/source/io/gpio/: io_gpio_prv.h io_gpio.c io_gpio.h
  group twrk60n512 User Config
    ../../../../config/twrk60n512/: user_config.h
  group Generic IO Drivers:io_mem
    ../../../../mqx/source/io/io_mem/: io_mem.c iomemprv.h io_mem.h
  group Peripheral IO Drivers:enet:phy
    ../../../../mqx/source/io/enet/phy/: phy_ksz8041.h phy_ksz8041.c
  group Peripheral IO Drivers:i2c:int
    ../../../../mqx/source/io/i2c/int/: i2c_int_prv.h i2c_int.c
  group Peripheral IO Drivers:gpio:knxx
    ../../../../mqx/source/io/gpio/kgpio/: io_gpio_kgpio_prv.h io_gpio_kgpio.h io_gpio_kgpio.c
target bsp_twrk60n512 Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: bsp (library)
  AfterMake: ../../../../mqx/build/bat/bsp_twrk60n512.bat ../../../.. ../../../../lib/twrk60n512.uv4/release/bsp uv4
  AfterMake: ../../../../mqx/build/bat/keil.bat .\bsp_twrk60n512_release\bsp.lib ..\..\..\..\lib\twrk60n512.uv4\release\bsp\bsp.lib
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  c include: as above
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
