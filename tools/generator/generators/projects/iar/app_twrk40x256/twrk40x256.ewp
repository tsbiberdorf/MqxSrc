# IAR project twrk40x256.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: twrk40x256.srec
  ILINK.IlinkOutputFile: twrk40x256.out
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
