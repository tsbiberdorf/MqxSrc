# IAR project twrk70f120m.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: twrk70f120m.srec
  ILINK.IlinkOutputFile: twrk70f120m.out
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCOptLevel: 3
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
