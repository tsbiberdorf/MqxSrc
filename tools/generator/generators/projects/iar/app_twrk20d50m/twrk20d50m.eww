<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\twrk20d50m.ewp</path>
  </project>
  <batchBuild/>
</workspace>


