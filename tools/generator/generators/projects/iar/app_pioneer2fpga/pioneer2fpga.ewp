# IAR project pioneer2fpga.ewp, settings and files
configuration Int Ram Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: pioneer2fpga.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Ram Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 3
