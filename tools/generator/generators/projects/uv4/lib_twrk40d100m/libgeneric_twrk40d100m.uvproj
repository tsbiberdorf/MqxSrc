# Keil uVision project libgeneric_twrk40d100m.uvproj, settings and files
target Debug (ARM-ADS)
  device: K40DX256M10 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: XXXlibrarynameXXX_twrk40d100m_d (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_twrk40d100m.bat" "..\..\..\lib\twrk40d100m.uv4\XXXlibrarynameXXX" uv4 debug twrk40d100m
  c flags: Optim=1 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, _DEBUG
  c misc: --c99
  asm misc: --cpreproc --diag_suppress=1609
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\twrk40d100m.uv4\mqx\intflash.scf
target Release (ARM-ADS)
  device: K40DX256M10 Freescale Semiconductor
  cpu: as above
  output: XXXlibrarynameXXX_twrk40d100m (library)
  AfterMake: "..\bat\XXXlibrarynameXXX_twrk40d100m.bat" "..\..\..\lib\twrk40d100m.uv4\XXXlibrarynameXXX" uv4 release twrk40d100m
  c flags: Optim=4 OneElfS=1
  c define: MQX_DISABLE_CONFIG_CHECK, NDEBUG
  c misc: --c99
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\lib\twrk40d100m.uv4\mqx\intflash.scf
