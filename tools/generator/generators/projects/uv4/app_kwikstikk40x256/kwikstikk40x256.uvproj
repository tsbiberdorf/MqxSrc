# Keil uVision project kwikstikk40x256.uvproj, settings and files
target Int Flash Debug (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: XXXappnameXXX_intflash_d +hex
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\lib\kwikstikk40x256.uv4\bsp\intflash.scf
  link misc: ../../../../lib/kwikstikk40x256.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../lib/kwikstikk40x256.uv4/debug/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
target Int Flash Release (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: as above
  output: XXXappnameXXX_inflash +hex
  c flags: Optim=4 OneElfS=1
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ..\..\..\..\lib\kwikstikk40x256.uv4\bsp\intflash.scf
  link misc: ../../../../lib/kwikstikk40x256.uv4/release/psp/psp.lib(linker_symbols.o)
../../../../lib/kwikstikk40x256.uv4/release/bsp/bsp.lib(vectors.o)
--keep linker_symbols.o(KERNEL_DATA_START)
--keep linker_symbols.o(KERNEL_DATA_END)
--keep linker_symbols.o(BOOT_STACK)
--keep vectors.o(.vectors_rom)
--diag_suppress=L6314W
